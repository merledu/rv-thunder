* NGSPICE file created from dff_ram_8x72.ext - technology: sky130A

* Black-box entry subcircuit for sky130_fd_sc_hd__mux2_1 abstract view
.subckt sky130_fd_sc_hd__mux2_1 A0 A1 S VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__fill_1 abstract view
.subckt sky130_fd_sc_hd__fill_1 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkbuf_1 abstract view
.subckt sky130_fd_sc_hd__clkbuf_1 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand2_1 abstract view
.subckt sky130_fd_sc_hd__nand2_1 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_ef_sc_hd__decap_12 abstract view
.subckt sky130_ef_sc_hd__decap_12 VPWR VGND VPB VNB
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_4 abstract view
.subckt sky130_fd_sc_hd__decap_4 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_8 abstract view
.subckt sky130_fd_sc_hd__decap_8 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__fill_2 abstract view
.subckt sky130_fd_sc_hd__fill_2 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dfxtp_1 abstract view
.subckt sky130_fd_sc_hd__dfxtp_1 CLK D VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__tapvpwrvgnd_1 abstract view
.subckt sky130_fd_sc_hd__tapvpwrvgnd_1 VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dlygate4sd3_1 abstract view
.subckt sky130_fd_sc_hd__dlygate4sd3_1 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_3 abstract view
.subckt sky130_fd_sc_hd__decap_3 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__mux4_1 abstract view
.subckt sky130_fd_sc_hd__mux4_1 A0 A1 A2 A3 S0 S1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_6 abstract view
.subckt sky130_fd_sc_hd__decap_6 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__buf_4 abstract view
.subckt sky130_fd_sc_hd__buf_4 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__diode_2 abstract view
.subckt sky130_fd_sc_hd__diode_2 DIODE VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__buf_1 abstract view
.subckt sky130_fd_sc_hd__buf_1 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkbuf_4 abstract view
.subckt sky130_fd_sc_hd__clkbuf_4 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__buf_2 abstract view
.subckt sky130_fd_sc_hd__buf_2 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkbuf_16 abstract view
.subckt sky130_fd_sc_hd__clkbuf_16 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and3_1 abstract view
.subckt sky130_fd_sc_hd__and3_1 A B C VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkbuf_8 abstract view
.subckt sky130_fd_sc_hd__clkbuf_8 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and3b_1 abstract view
.subckt sky130_fd_sc_hd__and3b_1 A_N B C VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dlymetal6s2s_1 abstract view
.subckt sky130_fd_sc_hd__dlymetal6s2s_1 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or3b_1 abstract view
.subckt sky130_fd_sc_hd__or3b_1 A B C_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor3_4 abstract view
.subckt sky130_fd_sc_hd__nor3_4 A B C VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor3b_4 abstract view
.subckt sky130_fd_sc_hd__nor3b_4 A B C_N VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor2_8 abstract view
.subckt sky130_fd_sc_hd__nor2_8 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor2b_4 abstract view
.subckt sky130_fd_sc_hd__nor2b_4 A B_N VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or2b_2 abstract view
.subckt sky130_fd_sc_hd__or2b_2 A B_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and2b_1 abstract view
.subckt sky130_fd_sc_hd__and2b_1 A_N B VGND VNB VPB VPWR X
.ends

.subckt dff_ram_8x72 VGND VPWR address[0] address[1] address[2] clk rdata[0] rdata[10]
+ rdata[11] rdata[12] rdata[13] rdata[14] rdata[15] rdata[16] rdata[17] rdata[18]
+ rdata[19] rdata[1] rdata[20] rdata[21] rdata[22] rdata[23] rdata[24] rdata[25] rdata[26]
+ rdata[27] rdata[28] rdata[29] rdata[2] rdata[30] rdata[31] rdata[32] rdata[33] rdata[34]
+ rdata[35] rdata[36] rdata[37] rdata[38] rdata[39] rdata[3] rdata[40] rdata[41] rdata[42]
+ rdata[43] rdata[44] rdata[45] rdata[46] rdata[47] rdata[48] rdata[49] rdata[4] rdata[50]
+ rdata[51] rdata[52] rdata[53] rdata[54] rdata[55] rdata[56] rdata[57] rdata[58]
+ rdata[59] rdata[5] rdata[60] rdata[61] rdata[62] rdata[63] rdata[64] rdata[65] rdata[66]
+ rdata[67] rdata[68] rdata[69] rdata[6] rdata[70] rdata[71] rdata[7] rdata[8] rdata[9]
+ wdata[0] wdata[10] wdata[11] wdata[12] wdata[13] wdata[14] wdata[15] wdata[16] wdata[17]
+ wdata[18] wdata[19] wdata[1] wdata[20] wdata[21] wdata[22] wdata[23] wdata[24] wdata[25]
+ wdata[26] wdata[27] wdata[28] wdata[29] wdata[2] wdata[30] wdata[31] wdata[32] wdata[33]
+ wdata[34] wdata[35] wdata[36] wdata[37] wdata[38] wdata[39] wdata[3] wdata[40] wdata[41]
+ wdata[42] wdata[43] wdata[44] wdata[45] wdata[46] wdata[47] wdata[48] wdata[49]
+ wdata[4] wdata[50] wdata[51] wdata[52] wdata[53] wdata[54] wdata[55] wdata[56] wdata[57]
+ wdata[58] wdata[59] wdata[5] wdata[60] wdata[61] wdata[62] wdata[63] wdata[64] wdata[65]
+ wdata[66] wdata[67] wdata[68] wdata[69] wdata[6] wdata[70] wdata[71] wdata[7] wdata[8]
+ wdata[9] wr
X_3155_ net429 _1229_ _1520_ VGND VGND VPWR VPWR _1521_ sky130_fd_sc_hd__mux2_1
XFILLER_0_27_60 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3086_ _1484_ VGND VGND VPWR VPWR _0305_ sky130_fd_sc_hd__clkbuf_1
X_2106_ net76 net3 VGND VGND VPWR VPWR _0810_ sky130_fd_sc_hd__nand2_1
XFILLER_0_89_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2037_ instance_1.rdata\[43\] instance_2.rdata\[43\] _0766_ VGND VGND VPWR VPWR _0770_
+ sky130_fd_sc_hd__mux2_1
XFILLER_0_49_314 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_76_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_9_444 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_43_92 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_91_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3988_ clknet_leaf_22_clk _0028_ VGND VGND VPWR VPWR instance_2.data\[2\]\[28\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_91_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2939_ _0880_ net423 _1406_ VGND VGND VPWR VPWR _1407_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_20_389 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4609_ clknet_leaf_62_clk _0649_ VGND VGND VPWR VPWR instance_2.data\[3\]\[1\] sky130_fd_sc_hd__dfxtp_1
Xhold362 instance_2.data\[1\]\[12\] VGND VGND VPWR VPWR net512 sky130_fd_sc_hd__dlygate4sd3_1
Xhold340 instance_1.data\[0\]\[11\] VGND VGND VPWR VPWR net490 sky130_fd_sc_hd__dlygate4sd3_1
Xhold351 instance_1.rdata\[20\] VGND VGND VPWR VPWR net501 sky130_fd_sc_hd__dlygate4sd3_1
Xhold373 instance_1.data\[0\]\[7\] VGND VGND VPWR VPWR net523 sky130_fd_sc_hd__dlygate4sd3_1
Xhold395 instance_1.data\[1\]\[62\] VGND VGND VPWR VPWR net545 sky130_fd_sc_hd__dlygate4sd3_1
Xhold384 instance_2.data\[2\]\[63\] VGND VGND VPWR VPWR net534 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_56_732 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_28_467 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_28_509 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_67_199 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_11_301 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_48_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_70_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_39_Left_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_3_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_64_14 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_48_Left_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_86_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3911_ _1918_ VGND VGND VPWR VPWR _0696_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_13_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3842_ _1882_ VGND VGND VPWR VPWR _0663_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_39_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3773_ _1845_ VGND VGND VPWR VPWR _0631_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_89_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_81_180 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2724_ instance_1.data\[0\]\[68\] instance_1.data\[1\]\[68\] instance_1.data\[2\]\[68\]
+ instance_1.data\[3\]\[68\] _0802_ _1258_ VGND VGND VPWR VPWR _1288_ sky130_fd_sc_hd__mux4_1
XFILLER_0_42_545 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_57_Left_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2655_ _1235_ VGND VGND VPWR VPWR _0123_ sky130_fd_sc_hd__clkbuf_1
X_2586_ net33 _1181_ _1165_ VGND VGND VPWR VPWR _1182_ sky130_fd_sc_hd__mux2_1
X_4325_ clknet_leaf_54_clk _0365_ VGND VGND VPWR VPWR instance_1.rdata\[5\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_10_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4256_ clknet_leaf_57_clk _0296_ VGND VGND VPWR VPWR instance_1.data\[3\]\[8\] sky130_fd_sc_hd__dfxtp_1
X_3207_ _1548_ VGND VGND VPWR VPWR _0362_ sky130_fd_sc_hd__clkbuf_1
X_4187_ clknet_leaf_48_clk _0227_ VGND VGND VPWR VPWR instance_2.data\[0\]\[11\] sky130_fd_sc_hd__dfxtp_1
X_3138_ net570 _1203_ _1509_ VGND VGND VPWR VPWR _1512_ sky130_fd_sc_hd__mux2_1
X_3069_ _1475_ VGND VGND VPWR VPWR _0297_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_49_100 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_49_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_53_702 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_25_437 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_49_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_9_252 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_92_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_60_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xhold170 instance_1.data\[3\]\[67\] VGND VGND VPWR VPWR net320 sky130_fd_sc_hd__dlygate4sd3_1
Xhold181 instance_1.data\[2\]\[17\] VGND VGND VPWR VPWR net331 sky130_fd_sc_hd__dlygate4sd3_1
Xhold192 instance_1.data\[2\]\[28\] VGND VGND VPWR VPWR net342 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_18_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_68_453 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_55_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_545 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_51_364 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_59_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2440_ instance_1.data\[0\]\[3\] instance_1.data\[1\]\[3\] instance_1.data\[2\]\[3\]
+ instance_1.data\[3\]\[3\] _0808_ _1054_ VGND VGND VPWR VPWR _1069_ sky130_fd_sc_hd__mux4_1
X_2371_ instance_2.data\[0\]\[60\] instance_2.data\[1\]\[60\] instance_2.data\[2\]\[60\]
+ instance_2.data\[3\]\[60\] _0991_ _1004_ VGND VGND VPWR VPWR _1015_ sky130_fd_sc_hd__mux4_1
X_4110_ clknet_leaf_55_clk _0150_ VGND VGND VPWR VPWR instance_2.data\[1\]\[6\] sky130_fd_sc_hd__dfxtp_1
X_4041_ clknet_leaf_57_clk _0081_ VGND VGND VPWR VPWR instance_1.data\[1\]\[9\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_67_838 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_86_283 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_22_407 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3825_ _1873_ VGND VGND VPWR VPWR _0655_ sky130_fd_sc_hd__clkbuf_1
X_3756_ _1836_ VGND VGND VPWR VPWR _0623_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_27_383 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_54_180 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2707_ _1275_ VGND VGND VPWR VPWR _0135_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_30_484 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_71_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3687_ _1800_ VGND VGND VPWR VPWR _0590_ sky130_fd_sc_hd__clkbuf_1
X_2638_ net46 _1221_ _1199_ VGND VGND VPWR VPWR _1222_ sky130_fd_sc_hd__mux2_1
X_2569_ net29 _1168_ _1165_ VGND VGND VPWR VPWR _1169_ sky130_fd_sc_hd__mux2_1
X_4308_ clknet_leaf_2_clk _0348_ VGND VGND VPWR VPWR instance_1.data\[3\]\[60\] sky130_fd_sc_hd__dfxtp_1
X_4239_ clknet_leaf_9_clk _0279_ VGND VGND VPWR VPWR instance_2.data\[0\]\[63\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_38_562 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_92_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_92_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_65_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_80_437 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_64_808 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_75_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_0_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_83_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_72_885 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_28_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_28_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4590_ clknet_leaf_15_clk _0630_ VGND VGND VPWR VPWR instance_1.data\[0\]\[54\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_9_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3610_ _0981_ net677 _1759_ VGND VGND VPWR VPWR _1760_ sky130_fd_sc_hd__mux2_1
X_3541_ _1723_ VGND VGND VPWR VPWR _0521_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_10_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_3_258 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3472_ _1687_ VGND VGND VPWR VPWR _0488_ sky130_fd_sc_hd__clkbuf_1
X_2423_ instance_1.data\[0\]\[0\] instance_1.data\[1\]\[0\] instance_1.data\[2\]\[0\]
+ instance_1.data\[3\]\[0\] _0808_ _1054_ VGND VGND VPWR VPWR _1055_ sky130_fd_sc_hd__mux4_1
X_2354_ _1001_ net55 _0978_ VGND VGND VPWR VPWR _1002_ sky130_fd_sc_hd__mux2_1
X_2285_ _0812_ VGND VGND VPWR VPWR _0949_ sky130_fd_sc_hd__buf_4
XFILLER_0_79_526 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4024_ clknet_leaf_9_clk _0064_ VGND VGND VPWR VPWR instance_2.data\[2\]\[64\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_35_532 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_47_412 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_74_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_34_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_34_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3808_ _1863_ VGND VGND VPWR VPWR _1864_ sky130_fd_sc_hd__buf_4
XFILLER_0_15_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3739_ _1827_ VGND VGND VPWR VPWR _0615_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_15_386 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_42_161 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_7_268 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_65_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_33_194 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_77_933 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2070_ instance_1.rdata\[59\] instance_2.rdata\[59\] _0777_ VGND VGND VPWR VPWR _0787_
+ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_49_668 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_76_518 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_88_389 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2972_ _0934_ net786 _1417_ VGND VGND VPWR VPWR _1424_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_32_502 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_84_551 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4642_ clknet_leaf_32_clk _0682_ VGND VGND VPWR VPWR instance_2.data\[3\]\[34\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_71_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_21_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4573_ clknet_leaf_30_clk _0613_ VGND VGND VPWR VPWR instance_1.data\[0\]\[37\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_4_545 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_21_95 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold703 instance_2.data\[0\]\[27\] VGND VGND VPWR VPWR net853 sky130_fd_sc_hd__dlygate4sd3_1
X_3524_ _1714_ VGND VGND VPWR VPWR _0513_ sky130_fd_sc_hd__clkbuf_1
Xhold714 instance_2.rdata\[62\] VGND VGND VPWR VPWR net864 sky130_fd_sc_hd__dlygate4sd3_1
X_3455_ _1678_ VGND VGND VPWR VPWR _0480_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_12_389 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2406_ _1041_ net68 _1012_ VGND VGND VPWR VPWR _1042_ sky130_fd_sc_hd__mux2_1
X_3386_ _1642_ VGND VGND VPWR VPWR _0447_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_4_238 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_34_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2337_ _0988_ net51 _0978_ VGND VGND VPWR VPWR _0989_ sky130_fd_sc_hd__mux2_1
X_2268_ _0935_ VGND VGND VPWR VPWR _0036_ sky130_fd_sc_hd__clkbuf_1
X_4007_ clknet_leaf_21_clk _0047_ VGND VGND VPWR VPWR instance_2.data\[2\]\[47\] sky130_fd_sc_hd__dfxtp_1
X_2199_ _0882_ VGND VGND VPWR VPWR _0020_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_62_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_30_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xhold41 instance_1.rdata\[52\] VGND VGND VPWR VPWR net191 sky130_fd_sc_hd__dlygate4sd3_1
Xhold30 instance_1.data\[2\]\[0\] VGND VGND VPWR VPWR net180 sky130_fd_sc_hd__dlygate4sd3_1
Xhold74 instance_1.data\[3\]\[48\] VGND VGND VPWR VPWR net224 sky130_fd_sc_hd__dlygate4sd3_1
Xhold63 instance_1.data\[2\]\[37\] VGND VGND VPWR VPWR net213 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_26_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xhold52 instance_2.data\[1\]\[56\] VGND VGND VPWR VPWR net202 sky130_fd_sc_hd__dlygate4sd3_1
Xhold85 instance_1.data\[2\]\[52\] VGND VGND VPWR VPWR net235 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_74_903 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_11_Left_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold96 instance_1.data\[2\]\[67\] VGND VGND VPWR VPWR net246 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_46_638 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_42_17 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_82_980 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_20_Left_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_5 net123 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_21_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3240_ _1565_ VGND VGND VPWR VPWR _0378_ sky130_fd_sc_hd__clkbuf_1
X_3171_ net624 _1256_ _1520_ VGND VGND VPWR VPWR _1529_ sky130_fd_sc_hd__mux2_1
XFILLER_0_83_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2122_ _0822_ net37 _0806_ VGND VGND VPWR VPWR _0823_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_1_208 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2053_ _0778_ VGND VGND VPWR VPWR net122 sky130_fd_sc_hd__buf_1
XFILLER_0_88_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_16_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_88_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_76_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_76_348 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_17_362 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_91_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_17_415 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2955_ _0907_ net720 _1406_ VGND VGND VPWR VPWR _1415_ sky130_fd_sc_hd__mux2_1
X_2886_ net819 _1042_ _1369_ VGND VGND VPWR VPWR _1378_ sky130_fd_sc_hd__mux2_1
X_4625_ clknet_leaf_51_clk _0665_ VGND VGND VPWR VPWR instance_2.data\[3\]\[17\] sky130_fd_sc_hd__dfxtp_1
Xhold500 instance_1.rdata\[43\] VGND VGND VPWR VPWR net650 sky130_fd_sc_hd__dlygate4sd3_1
X_4556_ clknet_leaf_40_clk _0596_ VGND VGND VPWR VPWR instance_1.data\[0\]\[20\] sky130_fd_sc_hd__dfxtp_1
Xhold511 instance_2.data\[0\]\[44\] VGND VGND VPWR VPWR net661 sky130_fd_sc_hd__dlygate4sd3_1
Xhold522 instance_1.data\[3\]\[34\] VGND VGND VPWR VPWR net672 sky130_fd_sc_hd__dlygate4sd3_1
X_3507_ _0815_ net768 _1704_ VGND VGND VPWR VPWR _1706_ sky130_fd_sc_hd__mux2_1
Xhold533 instance_2.data\[0\]\[2\] VGND VGND VPWR VPWR net683 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_12_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold544 instance_2.data\[1\]\[61\] VGND VGND VPWR VPWR net694 sky130_fd_sc_hd__dlygate4sd3_1
Xhold555 instance_1.data\[0\]\[35\] VGND VGND VPWR VPWR net705 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_12_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xhold577 instance_2.data\[0\]\[9\] VGND VGND VPWR VPWR net727 sky130_fd_sc_hd__dlygate4sd3_1
X_4487_ clknet_leaf_39_clk _0527_ VGND VGND VPWR VPWR instance_2.rdata\[23\] sky130_fd_sc_hd__dfxtp_1
Xhold566 instance_1.data\[0\]\[23\] VGND VGND VPWR VPWR net716 sky130_fd_sc_hd__dlygate4sd3_1
Xhold588 instance_2.data\[0\]\[70\] VGND VGND VPWR VPWR net738 sky130_fd_sc_hd__dlygate4sd3_1
X_3438_ net285 _1195_ _1669_ VGND VGND VPWR VPWR _1670_ sky130_fd_sc_hd__mux2_1
Xhold599 instance_2.data\[2\]\[67\] VGND VGND VPWR VPWR net749 sky130_fd_sc_hd__dlygate4sd3_1
X_3369_ _1633_ VGND VGND VPWR VPWR _0439_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_79_142 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_43_608 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_82_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_82_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_48_551 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_51_685 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_16_470 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_35_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_50_215 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput86 net86 VGND VGND VPWR VPWR rdata[18] sky130_fd_sc_hd__clkbuf_4
Xoutput97 net97 VGND VGND VPWR VPWR rdata[28] sky130_fd_sc_hd__buf_2
XTAP_TAPCELL_ROW_59_763 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_53_16 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_58_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_14_332 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2740_ _0810_ VGND VGND VPWR VPWR _1300_ sky130_fd_sc_hd__buf_4
X_2671_ net520 _1247_ _1230_ VGND VGND VPWR VPWR _1248_ sky130_fd_sc_hd__mux2_1
XFILLER_0_81_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_14_418 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4410_ clknet_leaf_43_clk _0450_ VGND VGND VPWR VPWR instance_1.data\[2\]\[18\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_41_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4341_ clknet_leaf_40_clk _0381_ VGND VGND VPWR VPWR instance_1.rdata\[21\] sky130_fd_sc_hd__dfxtp_1
X_4272_ clknet_leaf_41_clk _0312_ VGND VGND VPWR VPWR instance_1.data\[3\]\[24\] sky130_fd_sc_hd__dfxtp_1
X_3223_ net409 _1092_ _1556_ VGND VGND VPWR VPWR _1557_ sky130_fd_sc_hd__mux2_1
X_3154_ _1464_ VGND VGND VPWR VPWR _1520_ sky130_fd_sc_hd__buf_4
X_3085_ net437 _1117_ _1476_ VGND VGND VPWR VPWR _1484_ sky130_fd_sc_hd__mux2_1
X_2105_ net2 VGND VGND VPWR VPWR _0809_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_89_473 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_76_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2036_ _0769_ VGND VGND VPWR VPWR net113 sky130_fd_sc_hd__buf_1
X_3987_ clknet_leaf_38_clk _0027_ VGND VGND VPWR VPWR instance_2.data\[2\]\[27\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_91_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_256 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2938_ _1383_ VGND VGND VPWR VPWR _1406_ sky130_fd_sc_hd__buf_4
XFILLER_0_72_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_4_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2869_ _1302_ VGND VGND VPWR VPWR _1369_ sky130_fd_sc_hd__buf_4
X_4608_ clknet_leaf_62_clk _0648_ VGND VGND VPWR VPWR instance_2.data\[3\]\[0\] sky130_fd_sc_hd__dfxtp_1
Xhold352 instance_1.data\[0\]\[15\] VGND VGND VPWR VPWR net502 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_13_484 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4539_ clknet_leaf_61_clk _0579_ VGND VGND VPWR VPWR instance_1.data\[0\]\[3\] sky130_fd_sc_hd__dfxtp_1
Xhold330 instance_2.data\[0\]\[18\] VGND VGND VPWR VPWR net480 sky130_fd_sc_hd__dlygate4sd3_1
Xhold341 instance_1.data\[0\]\[68\] VGND VGND VPWR VPWR net491 sky130_fd_sc_hd__dlygate4sd3_1
Xhold385 instance_1.data\[1\]\[40\] VGND VGND VPWR VPWR net535 sky130_fd_sc_hd__dlygate4sd3_1
Xhold396 instance_2.data\[0\]\[16\] VGND VGND VPWR VPWR net546 sky130_fd_sc_hd__dlygate4sd3_1
Xhold374 instance_1.rdata\[67\] VGND VGND VPWR VPWR net524 sky130_fd_sc_hd__dlygate4sd3_1
Xhold363 instance_2.data\[2\]\[29\] VGND VGND VPWR VPWR net513 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_56_733 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_28_468 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_3_6__f_clk clknet_0_clk VGND VGND VPWR VPWR clknet_3_6__leaf_clk sky130_fd_sc_hd__clkbuf_16
XFILLER_0_67_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_11_302 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_31_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_48_49 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_64_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3910_ net461 _0975_ _1909_ VGND VGND VPWR VPWR _1918_ sky130_fd_sc_hd__mux2_1
X_3841_ net526 _0863_ _1876_ VGND VGND VPWR VPWR _1882_ sky130_fd_sc_hd__mux2_1
XFILLER_0_39_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3772_ net532 _1247_ _1839_ VGND VGND VPWR VPWR _1845_ sky130_fd_sc_hd__mux2_1
XFILLER_0_13_63 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2723_ _1287_ VGND VGND VPWR VPWR _0139_ sky130_fd_sc_hd__clkbuf_1
X_2654_ net350 _1234_ _1230_ VGND VGND VPWR VPWR _1235_ sky130_fd_sc_hd__mux2_1
X_2585_ instance_1.data\[0\]\[36\] instance_1.data\[1\]\[36\] instance_1.data\[2\]\[36\]
+ instance_1.data\[3\]\[36\] _1177_ _1156_ VGND VGND VPWR VPWR _1181_ sky130_fd_sc_hd__mux4_1
XFILLER_0_10_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4324_ clknet_leaf_58_clk _0364_ VGND VGND VPWR VPWR instance_1.rdata\[4\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_10_498 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4255_ clknet_leaf_57_clk _0295_ VGND VGND VPWR VPWR instance_1.data\[3\]\[7\] sky130_fd_sc_hd__dfxtp_1
X_4186_ clknet_leaf_49_clk _0226_ VGND VGND VPWR VPWR instance_2.data\[0\]\[10\] sky130_fd_sc_hd__dfxtp_1
X_3206_ net289 _1066_ _1545_ VGND VGND VPWR VPWR _1548_ sky130_fd_sc_hd__mux2_1
XFILLER_0_38_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3137_ _1511_ VGND VGND VPWR VPWR _0329_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_77_410 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3068_ net553 _1090_ _1465_ VGND VGND VPWR VPWR _1475_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_53_703 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2019_ _0760_ VGND VGND VPWR VPWR net104 sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_25_438 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_49_134 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_92_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_61_780 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xhold160 instance_1.data\[0\]\[39\] VGND VGND VPWR VPWR net310 sky130_fd_sc_hd__dlygate4sd3_1
Xhold171 instance_2.data\[3\]\[24\] VGND VGND VPWR VPWR net321 sky130_fd_sc_hd__dlygate4sd3_1
Xhold182 instance_1.data\[1\]\[56\] VGND VGND VPWR VPWR net332 sky130_fd_sc_hd__dlygate4sd3_1
Xhold193 instance_2.data\[2\]\[40\] VGND VGND VPWR VPWR net343 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_68_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_83_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_83_479 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_11_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2370_ _1014_ VGND VGND VPWR VPWR _0059_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_75_14 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4040_ clknet_leaf_56_clk _0080_ VGND VGND VPWR VPWR instance_1.data\[1\]\[8\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_67_839 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_91_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_86_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_22_408 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_15_502 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3824_ net595 _0836_ _1865_ VGND VGND VPWR VPWR _1873_ sky130_fd_sc_hd__mux2_1
X_3755_ net558 _1219_ _1828_ VGND VGND VPWR VPWR _1836_ sky130_fd_sc_hd__mux2_1
XFILLER_0_40_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3686_ net300 _1107_ _1795_ VGND VGND VPWR VPWR _1800_ sky130_fd_sc_hd__mux2_1
X_2706_ net836 _1274_ _1264_ VGND VGND VPWR VPWR _1275_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_30_485 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2637_ instance_1.data\[0\]\[48\] instance_1.data\[1\]\[48\] instance_1.data\[2\]\[48\]
+ instance_1.data\[3\]\[48\] _1211_ _1190_ VGND VGND VPWR VPWR _1221_ sky130_fd_sc_hd__mux4_1
XPHY_EDGE_ROW_12_Right_12 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_42_387 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_10_262 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_10_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2568_ instance_1.data\[0\]\[32\] instance_1.data\[1\]\[32\] instance_1.data\[2\]\[32\]
+ instance_1.data\[3\]\[32\] _1143_ _1156_ VGND VGND VPWR VPWR _1168_ sky130_fd_sc_hd__mux4_1
X_4307_ clknet_leaf_14_clk _0347_ VGND VGND VPWR VPWR instance_1.data\[3\]\[59\] sky130_fd_sc_hd__dfxtp_1
X_2499_ net154 _1114_ _1094_ VGND VGND VPWR VPWR _1115_ sky130_fd_sc_hd__mux2_1
XFILLER_0_49_92 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4238_ clknet_leaf_10_clk _0278_ VGND VGND VPWR VPWR instance_2.data\[0\]\[62\] sky130_fd_sc_hd__dfxtp_1
X_4169_ clknet_leaf_9_clk _0209_ VGND VGND VPWR VPWR instance_2.data\[1\]\[65\] sky130_fd_sc_hd__dfxtp_1
XPHY_EDGE_ROW_21_Right_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_38_563 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_65_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_92_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_80_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_18_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_30_Right_30 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_60_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_76_Left_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_64_809 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_85_Left_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_68_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_68_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_72_886 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_83_287 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_71_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_9_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3540_ _0869_ net862 _1715_ VGND VGND VPWR VPWR _1723_ sky130_fd_sc_hd__mux2_1
XFILLER_0_10_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_3_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3471_ net690 _1250_ _1680_ VGND VGND VPWR VPWR _1687_ sky130_fd_sc_hd__mux2_1
X_2422_ _0803_ VGND VGND VPWR VPWR _1054_ sky130_fd_sc_hd__clkbuf_4
X_2353_ instance_2.data\[0\]\[56\] instance_2.data\[1\]\[56\] instance_2.data\[2\]\[56\]
+ instance_2.data\[3\]\[56\] _0991_ _0970_ VGND VGND VPWR VPWR _1001_ sky130_fd_sc_hd__mux4_1
XFILLER_0_19_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4023_ clknet_leaf_9_clk _0063_ VGND VGND VPWR VPWR instance_2.data\[2\]\[63\] sky130_fd_sc_hd__dfxtp_1
X_2284_ _0947_ net38 _0944_ VGND VGND VPWR VPWR _0948_ sky130_fd_sc_hd__mux2_1
XFILLER_0_79_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_35_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_35_533 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_47_402 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_7_521 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3807_ _0808_ _0809_ _0810_ VGND VGND VPWR VPWR _1863_ sky130_fd_sc_hd__and3_1
XFILLER_0_27_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1999_ instance_1.rdata\[25\] instance_2.rdata\[25\] _0744_ VGND VGND VPWR VPWR _0750_
+ sky130_fd_sc_hd__mux2_1
X_3738_ net310 _1192_ _1817_ VGND VGND VPWR VPWR _1827_ sky130_fd_sc_hd__mux2_1
XFILLER_0_42_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3669_ net487 _1080_ _1784_ VGND VGND VPWR VPWR _1791_ sky130_fd_sc_hd__mux2_1
XFILLER_0_42_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_7_269 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_87_1030 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_77_934 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_leaf_58_clk clknet_3_1__leaf_clk VGND VGND VPWR VPWR clknet_leaf_58_clk sky130_fd_sc_hd__clkbuf_8
XTAP_TAPCELL_ROW_49_669 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_32_503 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2971_ _1423_ VGND VGND VPWR VPWR _0251_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_29_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_16_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_44_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4641_ clknet_leaf_32_clk _0681_ VGND VGND VPWR VPWR instance_2.data\[3\]\[33\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_71_268 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_40_580 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4572_ clknet_leaf_31_clk _0612_ VGND VGND VPWR VPWR instance_1.data\[0\]\[36\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_21_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_52_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xhold704 instance_2.rdata\[11\] VGND VGND VPWR VPWR net854 sky130_fd_sc_hd__dlygate4sd3_1
X_3523_ _0841_ net869 _1704_ VGND VGND VPWR VPWR _1714_ sky130_fd_sc_hd__mux2_1
XFILLER_0_24_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold715 instance_2.rdata\[47\] VGND VGND VPWR VPWR net865 sky130_fd_sc_hd__dlygate4sd3_1
X_3454_ net576 _1222_ _1669_ VGND VGND VPWR VPWR _1678_ sky130_fd_sc_hd__mux2_1
X_2405_ instance_2.data\[0\]\[68\] instance_2.data\[1\]\[68\] instance_2.data\[2\]\[68\]
+ instance_2.data\[3\]\[68\] _1025_ _0809_ VGND VGND VPWR VPWR _1041_ sky130_fd_sc_hd__mux4_1
X_3385_ net257 _1111_ _1636_ VGND VGND VPWR VPWR _1642_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_4_239 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2336_ instance_2.data\[0\]\[52\] instance_2.data\[1\]\[52\] instance_2.data\[2\]\[52\]
+ instance_2.data\[3\]\[52\] _0957_ _0970_ VGND VGND VPWR VPWR _0988_ sky130_fd_sc_hd__mux4_1
X_2267_ net163 _0934_ _0915_ VGND VGND VPWR VPWR _0935_ sky130_fd_sc_hd__mux2_1
Xclkbuf_leaf_49_clk clknet_3_4__leaf_clk VGND VGND VPWR VPWR clknet_leaf_49_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_0_27_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4006_ clknet_leaf_21_clk _0046_ VGND VGND VPWR VPWR instance_2.data\[2\]\[46\] sky130_fd_sc_hd__dfxtp_1
X_2198_ net572 _0880_ _0881_ VGND VGND VPWR VPWR _0882_ sky130_fd_sc_hd__mux2_1
XFILLER_0_1_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_90_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_47_298 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_62_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_35_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_15_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold31 instance_1.rdata\[54\] VGND VGND VPWR VPWR net181 sky130_fd_sc_hd__dlygate4sd3_1
Xhold20 instance_1.data\[3\]\[21\] VGND VGND VPWR VPWR net170 sky130_fd_sc_hd__dlygate4sd3_1
Xhold64 instance_1.data\[1\]\[50\] VGND VGND VPWR VPWR net214 sky130_fd_sc_hd__dlygate4sd3_1
Xhold42 instance_2.data\[1\]\[40\] VGND VGND VPWR VPWR net192 sky130_fd_sc_hd__dlygate4sd3_1
Xhold53 instance_2.data\[3\]\[54\] VGND VGND VPWR VPWR net203 sky130_fd_sc_hd__dlygate4sd3_1
Xhold86 instance_1.data\[0\]\[40\] VGND VGND VPWR VPWR net236 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_74_904 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xhold75 instance_1.rdata\[53\] VGND VGND VPWR VPWR net225 sky130_fd_sc_hd__dlygate4sd3_1
Xhold97 instance_2.data\[3\]\[28\] VGND VGND VPWR VPWR net247 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_46_639 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_82_981 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_42_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_66_541 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_81_511 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_53_202 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_34_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XANTENNA_6 net144 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_1_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_549 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_21_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3170_ _1528_ VGND VGND VPWR VPWR _0345_ sky130_fd_sc_hd__clkbuf_1
X_2121_ instance_2.data\[0\]\[3\] instance_2.data\[1\]\[3\] instance_2.data\[2\]\[3\]
+ instance_2.data\[3\]\[3\] _0821_ _0804_ VGND VGND VPWR VPWR _0822_ sky130_fd_sc_hd__mux4_1
X_2052_ instance_1.rdata\[50\] instance_2.rdata\[50\] _0777_ VGND VGND VPWR VPWR _0778_
+ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_1_209 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_88_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_16_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_88_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_76_338 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_17_363 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_17_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_72_500 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_17_427 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_32_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2954_ _1414_ VGND VGND VPWR VPWR _0243_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_44_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2885_ _1377_ VGND VGND VPWR VPWR _0211_ sky130_fd_sc_hd__clkbuf_1
X_4624_ clknet_leaf_47_clk _0664_ VGND VGND VPWR VPWR instance_2.data\[3\]\[16\] sky130_fd_sc_hd__dfxtp_1
XPHY_EDGE_ROW_6_Right_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold501 instance_2.data\[1\]\[13\] VGND VGND VPWR VPWR net651 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_4_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4555_ clknet_leaf_43_clk _0595_ VGND VGND VPWR VPWR instance_1.data\[0\]\[19\] sky130_fd_sc_hd__dfxtp_1
Xhold523 instance_1.data\[3\]\[13\] VGND VGND VPWR VPWR net673 sky130_fd_sc_hd__dlygate4sd3_1
Xhold534 instance_1.data\[3\]\[5\] VGND VGND VPWR VPWR net684 sky130_fd_sc_hd__dlygate4sd3_1
X_3506_ _1705_ VGND VGND VPWR VPWR _0504_ sky130_fd_sc_hd__clkbuf_1
Xhold512 instance_2.rdata\[0\] VGND VGND VPWR VPWR net662 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_40_452 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xhold545 instance_2.data\[0\]\[40\] VGND VGND VPWR VPWR net695 sky130_fd_sc_hd__dlygate4sd3_1
Xhold556 instance_1.data\[1\]\[1\] VGND VGND VPWR VPWR net706 sky130_fd_sc_hd__dlygate4sd3_1
Xhold578 instance_2.data\[1\]\[9\] VGND VGND VPWR VPWR net728 sky130_fd_sc_hd__dlygate4sd3_1
X_4486_ clknet_leaf_39_clk _0526_ VGND VGND VPWR VPWR instance_2.rdata\[22\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_40_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xhold567 instance_2.rdata\[26\] VGND VGND VPWR VPWR net717 sky130_fd_sc_hd__dlygate4sd3_1
X_3437_ net149 VGND VGND VPWR VPWR _1669_ sky130_fd_sc_hd__buf_4
Xhold589 instance_2.rdata\[2\] VGND VGND VPWR VPWR net739 sky130_fd_sc_hd__dlygate4sd3_1
X_3368_ net642 _1083_ _1625_ VGND VGND VPWR VPWR _1633_ sky130_fd_sc_hd__mux2_1
X_2319_ _0974_ net46 _0944_ VGND VGND VPWR VPWR _0975_ sky130_fd_sc_hd__mux2_1
X_3299_ _1596_ VGND VGND VPWR VPWR _0406_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_84_1000 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_67_316 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_43_609 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_75_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_51_686 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_90_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_7_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_50_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_50_227 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xoutput87 net87 VGND VGND VPWR VPWR rdata[19] sky130_fd_sc_hd__clkbuf_4
Xoutput98 net98 VGND VGND VPWR VPWR rdata[29] sky130_fd_sc_hd__buf_2
XTAP_TAPCELL_ROW_59_764 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_53_28 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_58_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_85_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_39_541 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_14_333 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_81_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_59_Right_59 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2670_ net54 _1246_ _1233_ VGND VGND VPWR VPWR _1247_ sky130_fd_sc_hd__mux2_1
XFILLER_0_41_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_1_313 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_22_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4340_ clknet_leaf_40_clk _0380_ VGND VGND VPWR VPWR instance_1.rdata\[20\] sky130_fd_sc_hd__dfxtp_1
X_4271_ clknet_leaf_41_clk _0311_ VGND VGND VPWR VPWR instance_1.data\[3\]\[23\] sky130_fd_sc_hd__dfxtp_1
X_3222_ _1544_ VGND VGND VPWR VPWR _1556_ sky130_fd_sc_hd__buf_4
X_3153_ _1519_ VGND VGND VPWR VPWR _0337_ sky130_fd_sc_hd__clkbuf_1
XPHY_EDGE_ROW_68_Right_68 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2104_ _0801_ VGND VGND VPWR VPWR _0808_ sky130_fd_sc_hd__clkbuf_8
XFILLER_0_89_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3084_ _1483_ VGND VGND VPWR VPWR _0304_ sky130_fd_sc_hd__clkbuf_1
X_2035_ instance_1.rdata\[42\] instance_2.rdata\[42\] _0766_ VGND VGND VPWR VPWR _0769_
+ sky130_fd_sc_hd__mux2_1
XFILLER_0_89_485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_91_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_77_Right_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_17_202 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3986_ clknet_leaf_38_clk _0026_ VGND VGND VPWR VPWR instance_2.data\[2\]\[26\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_91_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_72_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2937_ _1405_ VGND VGND VPWR VPWR _0235_ sky130_fd_sc_hd__clkbuf_1
X_4607_ clknet_leaf_54_clk _0647_ VGND VGND VPWR VPWR instance_1.data\[0\]\[71\] sky130_fd_sc_hd__dfxtp_1
X_2868_ _1368_ VGND VGND VPWR VPWR _0203_ sky130_fd_sc_hd__clkbuf_1
Xhold320 instance_2.data\[1\]\[1\] VGND VGND VPWR VPWR net470 sky130_fd_sc_hd__dlygate4sd3_1
X_2799_ _1332_ VGND VGND VPWR VPWR _0170_ sky130_fd_sc_hd__clkbuf_1
Xhold331 instance_2.rdata\[35\] VGND VGND VPWR VPWR net481 sky130_fd_sc_hd__dlygate4sd3_1
X_4538_ clknet_leaf_61_clk _0578_ VGND VGND VPWR VPWR instance_1.data\[0\]\[2\] sky130_fd_sc_hd__dfxtp_1
Xhold353 instance_1.data\[0\]\[24\] VGND VGND VPWR VPWR net503 sky130_fd_sc_hd__dlygate4sd3_1
Xhold342 instance_2.data\[1\]\[45\] VGND VGND VPWR VPWR net492 sky130_fd_sc_hd__dlygate4sd3_1
Xhold364 instance_1.data\[0\]\[57\] VGND VGND VPWR VPWR net514 sky130_fd_sc_hd__dlygate4sd3_1
X_4469_ clknet_leaf_54_clk _0509_ VGND VGND VPWR VPWR instance_2.rdata\[5\] sky130_fd_sc_hd__dfxtp_1
Xhold386 instance_1.data\[1\]\[60\] VGND VGND VPWR VPWR net536 sky130_fd_sc_hd__dlygate4sd3_1
Xhold375 instance_1.rdata\[32\] VGND VGND VPWR VPWR net525 sky130_fd_sc_hd__dlygate4sd3_1
XPHY_EDGE_ROW_86_Right_86 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold397 instance_1.data\[2\]\[61\] VGND VGND VPWR VPWR net547 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_56_734 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_28_469 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_67_135 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_11_303 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_36_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_51_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_63_352 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_51_547 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_48_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_86_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_80_59 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3840_ _1881_ VGND VGND VPWR VPWR _0662_ sky130_fd_sc_hd__clkbuf_1
X_3771_ _1844_ VGND VGND VPWR VPWR _0630_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_39_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_54_330 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2722_ net771 _1286_ _1264_ VGND VGND VPWR VPWR _1287_ sky130_fd_sc_hd__mux2_1
XFILLER_0_89_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_80_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_14_227 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_81_193 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2653_ net50 _1232_ _1233_ VGND VGND VPWR VPWR _1234_ sky130_fd_sc_hd__mux2_1
X_2584_ _1180_ VGND VGND VPWR VPWR _0107_ sky130_fd_sc_hd__clkbuf_1
X_4323_ clknet_leaf_58_clk _0363_ VGND VGND VPWR VPWR instance_1.rdata\[3\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_1_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_10_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4254_ clknet_leaf_58_clk _0294_ VGND VGND VPWR VPWR instance_1.data\[3\]\[6\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_38_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3205_ _1547_ VGND VGND VPWR VPWR _0361_ sky130_fd_sc_hd__clkbuf_1
X_4185_ clknet_leaf_50_clk _0225_ VGND VGND VPWR VPWR instance_2.data\[0\]\[9\] sky130_fd_sc_hd__dfxtp_1
X_3136_ net587 _1200_ _1509_ VGND VGND VPWR VPWR _1511_ sky130_fd_sc_hd__mux2_1
X_3067_ _1474_ VGND VGND VPWR VPWR _0296_ sky130_fd_sc_hd__clkbuf_1
X_2018_ instance_1.rdata\[34\] instance_2.rdata\[34\] _0755_ VGND VGND VPWR VPWR _0760_
+ sky130_fd_sc_hd__mux2_1
XFILLER_0_49_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_53_704 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_54_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_77_444 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_25_439 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_49_146 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_92_436 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_18_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_61_781 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3969_ clknet_leaf_56_clk _0009_ VGND VGND VPWR VPWR instance_2.data\[2\]\[9\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_60_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_20_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold161 instance_1.data\[2\]\[50\] VGND VGND VPWR VPWR net311 sky130_fd_sc_hd__dlygate4sd3_1
Xhold150 instance_1.data\[0\]\[14\] VGND VGND VPWR VPWR net300 sky130_fd_sc_hd__dlygate4sd3_1
Xhold183 instance_1.data\[0\]\[53\] VGND VGND VPWR VPWR net333 sky130_fd_sc_hd__dlygate4sd3_1
Xhold172 instance_1.data\[3\]\[60\] VGND VGND VPWR VPWR net322 sky130_fd_sc_hd__dlygate4sd3_1
Xhold194 instance_1.rdata\[39\] VGND VGND VPWR VPWR net344 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_55_127 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_24_514 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_91_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3823_ _1872_ VGND VGND VPWR VPWR _0654_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_22_409 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_6_202 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3754_ _1835_ VGND VGND VPWR VPWR _0622_ sky130_fd_sc_hd__clkbuf_1
X_3685_ _1799_ VGND VGND VPWR VPWR _0589_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_30_486 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2705_ net63 _1273_ _1267_ VGND VGND VPWR VPWR _1274_ sky130_fd_sc_hd__mux2_1
X_2636_ _1220_ VGND VGND VPWR VPWR _0119_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_57_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2567_ _1167_ VGND VGND VPWR VPWR _0103_ sky130_fd_sc_hd__clkbuf_1
X_4306_ clknet_leaf_14_clk _0346_ VGND VGND VPWR VPWR instance_1.data\[3\]\[58\] sky130_fd_sc_hd__dfxtp_1
X_2498_ net11 _1113_ _1097_ VGND VGND VPWR VPWR _1114_ sky130_fd_sc_hd__mux2_1
X_4237_ clknet_leaf_2_clk _0277_ VGND VGND VPWR VPWR instance_2.data\[0\]\[61\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_4_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4168_ clknet_leaf_9_clk _0208_ VGND VGND VPWR VPWR instance_2.data\[1\]\[64\] sky130_fd_sc_hd__dfxtp_1
X_3119_ net460 _1172_ _1498_ VGND VGND VPWR VPWR _1502_ sky130_fd_sc_hd__mux2_1
X_4099_ clknet_leaf_54_clk _0139_ VGND VGND VPWR VPWR instance_1.data\[1\]\[67\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_38_564 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_65_414 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_92_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_92_244 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_60_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_68_230 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_56_414 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_72_887 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_56_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_68_285 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3470_ _1686_ VGND VGND VPWR VPWR _0487_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_10_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_86_47 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2421_ _1053_ VGND VGND VPWR VPWR _0071_ sky130_fd_sc_hd__clkbuf_1
X_2352_ _1000_ VGND VGND VPWR VPWR _0055_ sky130_fd_sc_hd__clkbuf_1
X_2283_ instance_2.data\[0\]\[40\] instance_2.data\[1\]\[40\] instance_2.data\[2\]\[40\]
+ instance_2.data\[3\]\[40\] _0923_ _0936_ VGND VGND VPWR VPWR _0947_ sky130_fd_sc_hd__mux4_1
X_4022_ clknet_leaf_10_clk _0062_ VGND VGND VPWR VPWR instance_2.data\[2\]\[62\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_35_534 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_7_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_47_458 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3806_ _1862_ VGND VGND VPWR VPWR _0647_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_51_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3737_ _1826_ VGND VGND VPWR VPWR _0614_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_27_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1998_ _0749_ VGND VGND VPWR VPWR net93 sky130_fd_sc_hd__buf_1
XFILLER_0_42_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3668_ _1790_ VGND VGND VPWR VPWR _0581_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_42_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2619_ _1207_ VGND VGND VPWR VPWR _0115_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_2_271 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3599_ _0964_ net829 _1748_ VGND VGND VPWR VPWR _1754_ sky130_fd_sc_hd__mux2_1
XFILLER_0_61_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_77_935 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_84_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_32_504 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2970_ _0931_ net584 _1417_ VGND VGND VPWR VPWR _1423_ sky130_fd_sc_hd__mux2_1
XFILLER_0_44_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4640_ clknet_leaf_35_clk _0680_ VGND VGND VPWR VPWR instance_2.data\[3\]\[32\] sky130_fd_sc_hd__dfxtp_1
X_4571_ clknet_leaf_30_clk _0611_ VGND VGND VPWR VPWR instance_1.data\[0\]\[35\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_12_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_40_581 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3522_ _1713_ VGND VGND VPWR VPWR _0512_ sky130_fd_sc_hd__clkbuf_1
Xhold716 instance_2.rdata\[18\] VGND VGND VPWR VPWR net866 sky130_fd_sc_hd__dlygate4sd3_1
Xhold705 instance_2.data\[0\]\[64\] VGND VGND VPWR VPWR net855 sky130_fd_sc_hd__dlygate4sd3_1
X_3453_ _1677_ VGND VGND VPWR VPWR _0479_ sky130_fd_sc_hd__clkbuf_1
X_2404_ _1040_ VGND VGND VPWR VPWR _0067_ sky130_fd_sc_hd__clkbuf_1
X_3384_ _1641_ VGND VGND VPWR VPWR _0446_ sky130_fd_sc_hd__clkbuf_1
X_2335_ _0987_ VGND VGND VPWR VPWR _0051_ sky130_fd_sc_hd__clkbuf_1
X_2266_ _0933_ net33 _0910_ VGND VGND VPWR VPWR _0934_ sky130_fd_sc_hd__mux2_1
X_2197_ _0812_ VGND VGND VPWR VPWR _0881_ sky130_fd_sc_hd__buf_4
XFILLER_0_46_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4005_ clknet_leaf_21_clk _0045_ VGND VGND VPWR VPWR instance_2.data\[2\]\[45\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_79_358 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_90_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_90_545 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_62_236 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_62_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_15_196 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_30_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xhold32 instance_2.data\[1\]\[2\] VGND VGND VPWR VPWR net182 sky130_fd_sc_hd__dlygate4sd3_1
Xhold10 instance_1.data\[1\]\[29\] VGND VGND VPWR VPWR net160 sky130_fd_sc_hd__dlygate4sd3_1
Xhold21 instance_2.data\[1\]\[37\] VGND VGND VPWR VPWR net171 sky130_fd_sc_hd__dlygate4sd3_1
Xhold43 instance_2.data\[2\]\[2\] VGND VGND VPWR VPWR net193 sky130_fd_sc_hd__dlygate4sd3_1
Xhold54 instance_1.data\[2\]\[10\] VGND VGND VPWR VPWR net204 sky130_fd_sc_hd__dlygate4sd3_1
Xhold65 instance_2.data\[1\]\[71\] VGND VGND VPWR VPWR net215 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_74_905 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xhold76 instance_1.data\[3\]\[65\] VGND VGND VPWR VPWR net226 sky130_fd_sc_hd__dlygate4sd3_1
Xhold87 instance_2.data\[1\]\[24\] VGND VGND VPWR VPWR net237 sky130_fd_sc_hd__dlygate4sd3_1
Xhold98 instance_1.data\[1\]\[30\] VGND VGND VPWR VPWR net248 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_82_982 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_38_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_53_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_53_258 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_1_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_21_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2120_ _0801_ VGND VGND VPWR VPWR _0821_ sky130_fd_sc_hd__buf_4
X_2051_ _0721_ VGND VGND VPWR VPWR _0777_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_88_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_16_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_88_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_17_364 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2953_ _0904_ net853 _1406_ VGND VGND VPWR VPWR _1414_ sky130_fd_sc_hd__mux2_1
XFILLER_0_84_383 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_32_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2884_ net353 _1039_ _1369_ VGND VGND VPWR VPWR _1377_ sky130_fd_sc_hd__mux2_1
X_4623_ clknet_leaf_50_clk _0663_ VGND VGND VPWR VPWR instance_2.data\[3\]\[15\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_12_100 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4554_ clknet_leaf_44_clk _0594_ VGND VGND VPWR VPWR instance_1.data\[0\]\[18\] sky130_fd_sc_hd__dfxtp_1
Xhold502 instance_2.data\[3\]\[46\] VGND VGND VPWR VPWR net652 sky130_fd_sc_hd__dlygate4sd3_1
Xhold535 instance_1.data\[1\]\[48\] VGND VGND VPWR VPWR net685 sky130_fd_sc_hd__dlygate4sd3_1
Xhold513 instance_1.data\[3\]\[59\] VGND VGND VPWR VPWR net663 sky130_fd_sc_hd__dlygate4sd3_1
Xhold524 instance_2.data\[2\]\[19\] VGND VGND VPWR VPWR net674 sky130_fd_sc_hd__dlygate4sd3_1
X_3505_ _0805_ net662 _1704_ VGND VGND VPWR VPWR _1705_ sky130_fd_sc_hd__mux2_1
Xhold568 instance_2.data\[3\]\[33\] VGND VGND VPWR VPWR net718 sky130_fd_sc_hd__dlygate4sd3_1
Xhold579 instance_1.data\[3\]\[4\] VGND VGND VPWR VPWR net729 sky130_fd_sc_hd__dlygate4sd3_1
X_4485_ clknet_leaf_40_clk _0525_ VGND VGND VPWR VPWR instance_2.rdata\[21\] sky130_fd_sc_hd__dfxtp_1
Xhold546 instance_2.data\[3\]\[58\] VGND VGND VPWR VPWR net696 sky130_fd_sc_hd__dlygate4sd3_1
Xhold557 instance_2.rdata\[31\] VGND VGND VPWR VPWR net707 sky130_fd_sc_hd__dlygate4sd3_1
X_3436_ _1668_ VGND VGND VPWR VPWR _0471_ sky130_fd_sc_hd__clkbuf_1
X_3367_ _1632_ VGND VGND VPWR VPWR _0438_ sky130_fd_sc_hd__clkbuf_1
X_2318_ instance_2.data\[0\]\[48\] instance_2.data\[1\]\[48\] instance_2.data\[2\]\[48\]
+ instance_2.data\[3\]\[48\] _0957_ _0970_ VGND VGND VPWR VPWR _0974_ sky130_fd_sc_hd__mux4_1
X_3298_ net446 _1215_ _1589_ VGND VGND VPWR VPWR _1596_ sky130_fd_sc_hd__mux2_1
X_2249_ _0920_ net29 _0910_ VGND VGND VPWR VPWR _0921_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_84_1001 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_48_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_51_687 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_7_182 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_7_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput88 net88 VGND VGND VPWR VPWR rdata[1] sky130_fd_sc_hd__clkbuf_4
Xoutput99 net99 VGND VGND VPWR VPWR rdata[2] sky130_fd_sc_hd__clkbuf_4
Xoutput77 net77 VGND VGND VPWR VPWR rdata[0] sky130_fd_sc_hd__clkbuf_4
XFILLER_0_85_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_85_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_14_334 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_5_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_26_214 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4270_ clknet_leaf_40_clk _0310_ VGND VGND VPWR VPWR instance_1.data\[3\]\[22\] sky130_fd_sc_hd__dfxtp_1
X_3221_ _1555_ VGND VGND VPWR VPWR _0369_ sky130_fd_sc_hd__clkbuf_1
X_3152_ net165 _1226_ _1509_ VGND VGND VPWR VPWR _1519_ sky130_fd_sc_hd__mux2_1
X_2103_ _0805_ net4 _0806_ VGND VGND VPWR VPWR _0807_ sky130_fd_sc_hd__mux2_1
X_3083_ net675 _1114_ _1476_ VGND VGND VPWR VPWR _1483_ sky130_fd_sc_hd__mux2_1
X_2034_ _0768_ VGND VGND VPWR VPWR net112 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_89_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3985_ clknet_leaf_53_clk _0025_ VGND VGND VPWR VPWR instance_2.data\[2\]\[25\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_17_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_17_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2936_ _0877_ net847 _1395_ VGND VGND VPWR VPWR _1405_ sky130_fd_sc_hd__mux2_1
X_2867_ net197 _1013_ _1358_ VGND VGND VPWR VPWR _1368_ sky130_fd_sc_hd__mux2_1
XFILLER_0_87_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4606_ clknet_leaf_5_clk _0646_ VGND VGND VPWR VPWR instance_1.data\[0\]\[70\] sky130_fd_sc_hd__dfxtp_1
Xhold310 instance_1.data\[3\]\[33\] VGND VGND VPWR VPWR net460 sky130_fd_sc_hd__dlygate4sd3_1
X_2798_ net346 _0900_ _1325_ VGND VGND VPWR VPWR _1332_ sky130_fd_sc_hd__mux2_1
XFILLER_0_13_464 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold321 instance_2.data\[3\]\[10\] VGND VGND VPWR VPWR net471 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_7_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4537_ clknet_leaf_61_clk _0577_ VGND VGND VPWR VPWR instance_1.data\[0\]\[1\] sky130_fd_sc_hd__dfxtp_1
Xhold332 instance_2.data\[2\]\[70\] VGND VGND VPWR VPWR net482 sky130_fd_sc_hd__dlygate4sd3_1
Xhold343 instance_2.data\[3\]\[27\] VGND VGND VPWR VPWR net493 sky130_fd_sc_hd__dlygate4sd3_1
Xhold376 instance_2.data\[3\]\[15\] VGND VGND VPWR VPWR net526 sky130_fd_sc_hd__dlygate4sd3_1
X_4468_ clknet_leaf_58_clk _0508_ VGND VGND VPWR VPWR instance_2.rdata\[4\] sky130_fd_sc_hd__dfxtp_1
Xhold354 instance_1.rdata\[19\] VGND VGND VPWR VPWR net504 sky130_fd_sc_hd__dlygate4sd3_1
Xhold365 instance_1.data\[1\]\[25\] VGND VGND VPWR VPWR net515 sky130_fd_sc_hd__dlygate4sd3_1
Xhold387 instance_1.rdata\[33\] VGND VGND VPWR VPWR net537 sky130_fd_sc_hd__dlygate4sd3_1
Xhold398 instance_1.data\[3\]\[25\] VGND VGND VPWR VPWR net548 sky130_fd_sc_hd__dlygate4sd3_1
X_3419_ net359 _1166_ _1658_ VGND VGND VPWR VPWR _1660_ sky130_fd_sc_hd__mux2_1
X_4399_ clknet_leaf_57_clk _0439_ VGND VGND VPWR VPWR instance_1.data\[2\]\[7\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_56_735 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_67_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_82_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_11_304 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_36_545 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_63_364 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_23_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_31_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_48_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_58_114 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_80_38 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_80_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_17_Left_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3770_ net745 _1243_ _1839_ VGND VGND VPWR VPWR _1844_ sky130_fd_sc_hd__mux2_1
X_2721_ net67 _1285_ _1267_ VGND VGND VPWR VPWR _1286_ sky130_fd_sc_hd__mux2_1
XFILLER_0_42_504 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_54_342 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_89_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2652_ _1045_ VGND VGND VPWR VPWR _1233_ sky130_fd_sc_hd__buf_4
X_2583_ net412 _1179_ _1162_ VGND VGND VPWR VPWR _1180_ sky130_fd_sc_hd__mux2_1
X_4322_ clknet_leaf_60_clk _0362_ VGND VGND VPWR VPWR instance_1.rdata\[2\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_1_155 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4253_ clknet_leaf_55_clk _0293_ VGND VGND VPWR VPWR instance_1.data\[3\]\[5\] sky130_fd_sc_hd__dfxtp_1
X_3204_ net463 _1062_ _1545_ VGND VGND VPWR VPWR _1547_ sky130_fd_sc_hd__mux2_1
X_4184_ clknet_leaf_56_clk _0224_ VGND VGND VPWR VPWR instance_2.data\[0\]\[8\] sky130_fd_sc_hd__dfxtp_1
X_3135_ _1510_ VGND VGND VPWR VPWR _0328_ sky130_fd_sc_hd__clkbuf_1
X_3066_ net375 _1086_ _1465_ VGND VGND VPWR VPWR _1474_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_53_705 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2017_ _0759_ VGND VGND VPWR VPWR net103 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_49_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_92_426 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_92_415 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_49_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_49_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_18_545 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3968_ clknet_leaf_56_clk _0008_ VGND VGND VPWR VPWR instance_2.data\[2\]\[8\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_64_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2919_ _1396_ VGND VGND VPWR VPWR _0226_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_61_782 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3899_ _1912_ VGND VGND VPWR VPWR _0690_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_60_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xhold162 instance_1.data\[1\]\[42\] VGND VGND VPWR VPWR net312 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_13_294 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold151 instance_1.rdata\[8\] VGND VGND VPWR VPWR net301 sky130_fd_sc_hd__dlygate4sd3_1
Xhold140 instance_2.data\[2\]\[26\] VGND VGND VPWR VPWR net290 sky130_fd_sc_hd__dlygate4sd3_1
Xhold184 instance_1.rdata\[60\] VGND VGND VPWR VPWR net334 sky130_fd_sc_hd__dlygate4sd3_1
Xhold173 instance_2.data\[3\]\[49\] VGND VGND VPWR VPWR net323 sky130_fd_sc_hd__dlygate4sd3_1
Xhold195 instance_2.data\[3\]\[53\] VGND VGND VPWR VPWR net345 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_68_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_28_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_24_526 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_51_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_91_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_86_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_24_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_46_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3822_ net216 _0832_ _1865_ VGND VGND VPWR VPWR _1872_ sky130_fd_sc_hd__mux2_1
X_3753_ net456 _1216_ _1828_ VGND VGND VPWR VPWR _1835_ sky130_fd_sc_hd__mux2_1
XFILLER_0_54_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3684_ net243 _1104_ _1795_ VGND VGND VPWR VPWR _1799_ sky130_fd_sc_hd__mux2_1
X_2704_ instance_1.data\[0\]\[63\] instance_1.data\[1\]\[63\] instance_1.data\[2\]\[63\]
+ instance_1.data\[3\]\[63\] _1245_ _1258_ VGND VGND VPWR VPWR _1273_ sky130_fd_sc_hd__mux4_1
XTAP_TAPCELL_ROW_30_487 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_42_323 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2635_ net596 _1219_ _1196_ VGND VGND VPWR VPWR _1220_ sky130_fd_sc_hd__mux2_1
XFILLER_0_30_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4305_ clknet_leaf_14_clk _0345_ VGND VGND VPWR VPWR instance_1.data\[3\]\[57\] sky130_fd_sc_hd__dfxtp_1
X_2566_ net649 _1166_ _1162_ VGND VGND VPWR VPWR _1167_ sky130_fd_sc_hd__mux2_1
X_2497_ instance_1.data\[0\]\[16\] instance_1.data\[1\]\[16\] instance_1.data\[2\]\[16\]
+ instance_1.data\[3\]\[16\] _1109_ _1088_ VGND VGND VPWR VPWR _1113_ sky130_fd_sc_hd__mux4_1
XFILLER_0_49_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_4_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4236_ clknet_leaf_9_clk _0276_ VGND VGND VPWR VPWR instance_2.data\[0\]\[60\] sky130_fd_sc_hd__dfxtp_1
X_4167_ clknet_leaf_9_clk _0207_ VGND VGND VPWR VPWR instance_2.data\[1\]\[63\] sky130_fd_sc_hd__dfxtp_1
X_3118_ _1501_ VGND VGND VPWR VPWR _0320_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_66_830 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4098_ clknet_leaf_0_clk _0138_ VGND VGND VPWR VPWR instance_1.data\[1\]\[66\] sky130_fd_sc_hd__dfxtp_1
X_3049_ _1464_ VGND VGND VPWR VPWR _1465_ sky130_fd_sc_hd__buf_4
XTAP_TAPCELL_ROW_38_565 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_81_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_92_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_92_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_18_386 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_33_312 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_33_367 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_60_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_68_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_72_888 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_28_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_28_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_10_88 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_10_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2420_ net475 _1052_ _0812_ VGND VGND VPWR VPWR _1053_ sky130_fd_sc_hd__mux2_1
XFILLER_0_86_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_86_59 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2351_ net585 _0999_ _0983_ VGND VGND VPWR VPWR _1000_ sky130_fd_sc_hd__mux2_1
X_2282_ _0946_ VGND VGND VPWR VPWR _0039_ sky130_fd_sc_hd__clkbuf_1
X_4021_ clknet_leaf_10_clk _0061_ VGND VGND VPWR VPWR instance_2.data\[2\]\[61\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_63_800 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_35_535 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_19_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_7_545 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3805_ net623 _1298_ net150 VGND VGND VPWR VPWR _1862_ sky130_fd_sc_hd__mux2_1
X_1997_ instance_1.rdata\[24\] instance_2.rdata\[24\] _0744_ VGND VGND VPWR VPWR _0749_
+ sky130_fd_sc_hd__mux2_1
X_3736_ net586 _1188_ _1817_ VGND VGND VPWR VPWR _1826_ sky130_fd_sc_hd__mux2_1
XFILLER_0_42_120 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_30_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3667_ net198 _1077_ _1784_ VGND VGND VPWR VPWR _1790_ sky130_fd_sc_hd__mux2_1
X_2618_ net653 _1206_ _1196_ VGND VGND VPWR VPWR _1207_ sky130_fd_sc_hd__mux2_1
X_3598_ _1753_ VGND VGND VPWR VPWR _0548_ sky130_fd_sc_hd__clkbuf_1
X_2549_ instance_1.data\[0\]\[28\] instance_1.data\[1\]\[28\] instance_1.data\[2\]\[28\]
+ instance_1.data\[3\]\[28\] _1143_ _1122_ VGND VGND VPWR VPWR _1153_ sky130_fd_sc_hd__mux4_1
X_4219_ clknet_leaf_22_clk _0259_ VGND VGND VPWR VPWR instance_2.data\[0\]\[43\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_18_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_21_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_6_260 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_32_505 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_56_234 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4570_ clknet_leaf_31_clk _0610_ VGND VGND VPWR VPWR instance_1.data\[0\]\[34\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_4_504 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3521_ _0838_ net790 _1704_ VGND VGND VPWR VPWR _1713_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_40_582 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_12_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_24_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold706 instance_2.data\[1\]\[64\] VGND VGND VPWR VPWR net856 sky130_fd_sc_hd__dlygate4sd3_1
Xhold717 instance_2.rdata\[59\] VGND VGND VPWR VPWR net867 sky130_fd_sc_hd__dlygate4sd3_1
X_3452_ net578 _1219_ _1669_ VGND VGND VPWR VPWR _1677_ sky130_fd_sc_hd__mux2_1
XFILLER_0_12_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3383_ net189 _1107_ _1636_ VGND VGND VPWR VPWR _1641_ sky130_fd_sc_hd__mux2_1
X_2403_ net749 _1039_ _1017_ VGND VGND VPWR VPWR _1040_ sky130_fd_sc_hd__mux2_1
X_2334_ net608 _0986_ _0983_ VGND VGND VPWR VPWR _0987_ sky130_fd_sc_hd__mux2_1
X_2265_ instance_2.data\[0\]\[36\] instance_2.data\[1\]\[36\] instance_2.data\[2\]\[36\]
+ instance_2.data\[3\]\[36\] _0923_ _0902_ VGND VGND VPWR VPWR _0933_ sky130_fd_sc_hd__mux4_1
X_2196_ _0879_ net16 _0876_ VGND VGND VPWR VPWR _0880_ sky130_fd_sc_hd__mux2_1
X_4004_ clknet_leaf_21_clk _0044_ VGND VGND VPWR VPWR instance_2.data\[2\]\[44\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_79_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_9_Left_102 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_48_660 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_1_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_47_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_62_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_90_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_386 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3719_ _1783_ VGND VGND VPWR VPWR _1817_ sky130_fd_sc_hd__buf_4
XFILLER_0_30_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold22 instance_2.data\[3\]\[38\] VGND VGND VPWR VPWR net172 sky130_fd_sc_hd__dlygate4sd3_1
Xhold11 instance_1.data\[1\]\[27\] VGND VGND VPWR VPWR net161 sky130_fd_sc_hd__dlygate4sd3_1
Xhold55 instance_1.data\[3\]\[7\] VGND VGND VPWR VPWR net205 sky130_fd_sc_hd__dlygate4sd3_1
Xhold44 instance_1.data\[1\]\[18\] VGND VGND VPWR VPWR net194 sky130_fd_sc_hd__dlygate4sd3_1
Xhold33 instance_2.data\[2\]\[30\] VGND VGND VPWR VPWR net183 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_74_906 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xhold66 instance_2.data\[3\]\[6\] VGND VGND VPWR VPWR net216 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_3_230 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xhold88 instance_1.data\[1\]\[17\] VGND VGND VPWR VPWR net238 sky130_fd_sc_hd__dlygate4sd3_1
Xhold77 instance_1.data\[2\]\[22\] VGND VGND VPWR VPWR net227 sky130_fd_sc_hd__dlygate4sd3_1
Xhold99 instance_1.rdata\[70\] VGND VGND VPWR VPWR net249 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_82_983 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_81_546 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_53_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_34_495 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_61_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_1_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2050_ _0776_ VGND VGND VPWR VPWR net120 sky130_fd_sc_hd__buf_1
XFILLER_0_16_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_45_630 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_88_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_17_365 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2952_ _1413_ VGND VGND VPWR VPWR _0242_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_84_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_29_267 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_32_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2883_ _1376_ VGND VGND VPWR VPWR _0210_ sky130_fd_sc_hd__clkbuf_1
X_4622_ clknet_leaf_48_clk _0662_ VGND VGND VPWR VPWR instance_2.data\[3\]\[14\] sky130_fd_sc_hd__dfxtp_1
X_4553_ clknet_leaf_42_clk _0593_ VGND VGND VPWR VPWR instance_1.data\[0\]\[17\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_40_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold503 instance_1.data\[1\]\[43\] VGND VGND VPWR VPWR net653 sky130_fd_sc_hd__dlygate4sd3_1
Xhold525 instance_1.data\[3\]\[16\] VGND VGND VPWR VPWR net675 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_4_378 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3504_ _1300_ VGND VGND VPWR VPWR _1704_ sky130_fd_sc_hd__buf_4
Xhold514 instance_2.data\[3\]\[19\] VGND VGND VPWR VPWR net664 sky130_fd_sc_hd__dlygate4sd3_1
Xhold536 instance_1.data\[0\]\[66\] VGND VGND VPWR VPWR net686 sky130_fd_sc_hd__dlygate4sd3_1
X_4484_ clknet_leaf_40_clk _0524_ VGND VGND VPWR VPWR instance_2.rdata\[20\] sky130_fd_sc_hd__dfxtp_1
X_3435_ net208 _1192_ _1658_ VGND VGND VPWR VPWR _1668_ sky130_fd_sc_hd__mux2_1
Xhold547 instance_1.rdata\[4\] VGND VGND VPWR VPWR net697 sky130_fd_sc_hd__dlygate4sd3_1
Xhold558 instance_2.rdata\[70\] VGND VGND VPWR VPWR net708 sky130_fd_sc_hd__dlygate4sd3_1
Xhold569 instance_2.data\[1\]\[60\] VGND VGND VPWR VPWR net719 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_12_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_0_551 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3366_ net583 _1080_ _1625_ VGND VGND VPWR VPWR _1632_ sky130_fd_sc_hd__mux2_1
X_3297_ _1595_ VGND VGND VPWR VPWR _0405_ sky130_fd_sc_hd__clkbuf_1
X_2317_ _0973_ VGND VGND VPWR VPWR _0047_ sky130_fd_sc_hd__clkbuf_1
X_2248_ instance_2.data\[0\]\[32\] instance_2.data\[1\]\[32\] instance_2.data\[2\]\[32\]
+ instance_2.data\[3\]\[32\] _0889_ _0902_ VGND VGND VPWR VPWR _0920_ sky130_fd_sc_hd__mux4_1
XTAP_TAPCELL_ROW_0_200 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_84_1002 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_79_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2179_ net256 _0866_ _0847_ VGND VGND VPWR VPWR _0867_ sky130_fd_sc_hd__mux2_1
XFILLER_0_79_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_63_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_51_688 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_63_524 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_90_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_16_440 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xoutput78 net78 VGND VGND VPWR VPWR rdata[10] sky130_fd_sc_hd__clkbuf_4
Xoutput89 net89 VGND VGND VPWR VPWR rdata[20] sky130_fd_sc_hd__clkbuf_4
XFILLER_0_39_521 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_42_600 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_335 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_26_226 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_22_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_1_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3220_ net206 _1089_ _1545_ VGND VGND VPWR VPWR _1555_ sky130_fd_sc_hd__mux2_1
X_3151_ _1518_ VGND VGND VPWR VPWR _0336_ sky130_fd_sc_hd__clkbuf_1
X_2102_ _0720_ VGND VGND VPWR VPWR _0806_ sky130_fd_sc_hd__buf_4
X_3082_ _1482_ VGND VGND VPWR VPWR _0303_ sky130_fd_sc_hd__clkbuf_1
X_2033_ instance_1.rdata\[41\] instance_2.rdata\[41\] _0766_ VGND VGND VPWR VPWR _0768_
+ sky130_fd_sc_hd__mux2_1
X_3984_ clknet_leaf_53_clk _0024_ VGND VGND VPWR VPWR instance_2.data\[2\]\[24\] sky130_fd_sc_hd__dfxtp_1
X_2935_ _1404_ VGND VGND VPWR VPWR _0234_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_72_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_72_343 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2866_ _1367_ VGND VGND VPWR VPWR _0202_ sky130_fd_sc_hd__clkbuf_1
X_4605_ clknet_leaf_4_clk _0645_ VGND VGND VPWR VPWR instance_1.data\[0\]\[69\] sky130_fd_sc_hd__dfxtp_1
Xhold300 instance_1.data\[3\]\[1\] VGND VGND VPWR VPWR net450 sky130_fd_sc_hd__dlygate4sd3_1
X_2797_ _1331_ VGND VGND VPWR VPWR _0169_ sky130_fd_sc_hd__clkbuf_1
Xhold311 instance_2.data\[3\]\[48\] VGND VGND VPWR VPWR net461 sky130_fd_sc_hd__dlygate4sd3_1
Xhold333 instance_1.data\[2\]\[42\] VGND VGND VPWR VPWR net483 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_4_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4536_ clknet_leaf_59_clk _0576_ VGND VGND VPWR VPWR instance_1.data\[0\]\[0\] sky130_fd_sc_hd__dfxtp_1
Xhold344 instance_2.data\[3\]\[0\] VGND VGND VPWR VPWR net494 sky130_fd_sc_hd__dlygate4sd3_1
Xhold322 instance_2.data\[2\]\[61\] VGND VGND VPWR VPWR net472 sky130_fd_sc_hd__dlygate4sd3_1
Xhold377 instance_1.rdata\[48\] VGND VGND VPWR VPWR net527 sky130_fd_sc_hd__dlygate4sd3_1
Xhold366 instance_1.data\[1\]\[8\] VGND VGND VPWR VPWR net516 sky130_fd_sc_hd__dlygate4sd3_1
X_4467_ clknet_leaf_58_clk _0507_ VGND VGND VPWR VPWR instance_2.rdata\[3\] sky130_fd_sc_hd__dfxtp_1
Xhold355 instance_1.data\[0\]\[4\] VGND VGND VPWR VPWR net505 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_90_1050 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4398_ clknet_leaf_58_clk _0438_ VGND VGND VPWR VPWR instance_1.data\[2\]\[6\] sky130_fd_sc_hd__dfxtp_1
Xhold399 instance_1.data\[0\]\[19\] VGND VGND VPWR VPWR net549 sky130_fd_sc_hd__dlygate4sd3_1
Xhold388 instance_2.data\[1\]\[22\] VGND VGND VPWR VPWR net538 sky130_fd_sc_hd__dlygate4sd3_1
X_3418_ _1659_ VGND VGND VPWR VPWR _0462_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_68_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3349_ _1622_ VGND VGND VPWR VPWR _0430_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_56_736 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_63_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_11_305 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_51_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_90_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_86_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_27_460 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_58_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_13_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_89_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2720_ instance_1.data\[0\]\[67\] instance_1.data\[1\]\[67\] instance_1.data\[2\]\[67\]
+ instance_1.data\[3\]\[67\] _0802_ _1258_ VGND VGND VPWR VPWR _1285_ sky130_fd_sc_hd__mux4_1
X_2651_ instance_1.data\[0\]\[51\] instance_1.data\[1\]\[51\] instance_1.data\[2\]\[51\]
+ instance_1.data\[3\]\[51\] _1211_ _1224_ VGND VGND VPWR VPWR _1232_ sky130_fd_sc_hd__mux4_1
XFILLER_0_42_516 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_54_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_81_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2582_ net32 _1178_ _1165_ VGND VGND VPWR VPWR _1179_ sky130_fd_sc_hd__mux2_1
XFILLER_0_10_435 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4321_ clknet_leaf_60_clk _0361_ VGND VGND VPWR VPWR instance_1.rdata\[1\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_66_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4252_ clknet_leaf_58_clk _0292_ VGND VGND VPWR VPWR instance_1.data\[3\]\[4\] sky130_fd_sc_hd__dfxtp_1
X_3203_ _1546_ VGND VGND VPWR VPWR _0360_ sky130_fd_sc_hd__clkbuf_1
X_4183_ clknet_leaf_50_clk _0223_ VGND VGND VPWR VPWR instance_2.data\[0\]\[7\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_38_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3134_ net575 _1195_ _1509_ VGND VGND VPWR VPWR _1510_ sky130_fd_sc_hd__mux2_1
X_3065_ _1473_ VGND VGND VPWR VPWR _0295_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_77_402 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2016_ instance_1.rdata\[33\] instance_2.rdata\[33\] _0755_ VGND VGND VPWR VPWR _0759_
+ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_53_706 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_92_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_92_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3967_ clknet_leaf_56_clk _0007_ VGND VGND VPWR VPWR instance_2.data\[2\]\[7\] sky130_fd_sc_hd__dfxtp_1
X_2918_ _0846_ net822 _1395_ VGND VGND VPWR VPWR _1396_ sky130_fd_sc_hd__mux2_1
XFILLER_0_9_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_61_783 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_leaf_30_clk clknet_3_7__leaf_clk VGND VGND VPWR VPWR clknet_leaf_30_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_0_33_516 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_45_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3898_ net722 _0955_ _1909_ VGND VGND VPWR VPWR _1912_ sky130_fd_sc_hd__mux2_1
XFILLER_0_72_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2849_ net266 _0982_ _1358_ VGND VGND VPWR VPWR _1359_ sky130_fd_sc_hd__mux2_1
Xhold130 instance_2.data\[2\]\[11\] VGND VGND VPWR VPWR net280 sky130_fd_sc_hd__dlygate4sd3_1
Xhold152 instance_2.data\[2\]\[8\] VGND VGND VPWR VPWR net302 sky130_fd_sc_hd__dlygate4sd3_1
Xhold141 instance_2.data\[3\]\[71\] VGND VGND VPWR VPWR net291 sky130_fd_sc_hd__dlygate4sd3_1
X_4519_ clknet_leaf_13_clk _0559_ VGND VGND VPWR VPWR instance_2.rdata\[55\] sky130_fd_sc_hd__dfxtp_1
Xhold174 instance_2.data\[1\]\[35\] VGND VGND VPWR VPWR net324 sky130_fd_sc_hd__dlygate4sd3_1
Xhold185 instance_1.rdata\[5\] VGND VGND VPWR VPWR net335 sky130_fd_sc_hd__dlygate4sd3_1
Xhold163 instance_2.data\[3\]\[62\] VGND VGND VPWR VPWR net313 sky130_fd_sc_hd__dlygate4sd3_1
Xhold196 instance_2.data\[1\]\[26\] VGND VGND VPWR VPWR net346 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_24_430 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_76_490 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkbuf_leaf_21_clk clknet_3_3__leaf_clk VGND VGND VPWR VPWR clknet_leaf_21_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_0_51_346 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_91_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_59_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3821_ _1871_ VGND VGND VPWR VPWR _0653_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_6_215 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_82_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3752_ _1834_ VGND VGND VPWR VPWR _0621_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_15_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_27_387 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_42_313 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_leaf_12_clk clknet_3_2__leaf_clk VGND VGND VPWR VPWR clknet_leaf_12_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_0_15_549 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3683_ _1798_ VGND VGND VPWR VPWR _0588_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_30_488 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2703_ _1272_ VGND VGND VPWR VPWR _0134_ sky130_fd_sc_hd__clkbuf_1
X_2634_ net45 _1218_ _1199_ VGND VGND VPWR VPWR _1219_ sky130_fd_sc_hd__mux2_1
X_2565_ net28 _1164_ _1165_ VGND VGND VPWR VPWR _1166_ sky130_fd_sc_hd__mux2_1
X_4304_ clknet_leaf_14_clk _0344_ VGND VGND VPWR VPWR instance_1.data\[3\]\[56\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_49_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2496_ _1112_ VGND VGND VPWR VPWR _0087_ sky130_fd_sc_hd__clkbuf_1
X_4235_ clknet_leaf_10_clk _0275_ VGND VGND VPWR VPWR instance_2.data\[0\]\[59\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_4_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4166_ clknet_leaf_10_clk _0206_ VGND VGND VPWR VPWR instance_2.data\[1\]\[62\] sky130_fd_sc_hd__dfxtp_1
X_3117_ net466 _1169_ _1498_ VGND VGND VPWR VPWR _1501_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_66_831 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4097_ clknet_leaf_5_clk _0137_ VGND VGND VPWR VPWR instance_1.data\[1\]\[65\] sky130_fd_sc_hd__dfxtp_1
X_3048_ _1463_ VGND VGND VPWR VPWR _1464_ sky130_fd_sc_hd__buf_4
XTAP_TAPCELL_ROW_21_400 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_92_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_36_Left_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_33_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_45_Left_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_68_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_56_427 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_71_408 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_54_Left_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_86_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2350_ _0998_ net54 _0978_ VGND VGND VPWR VPWR _0999_ sky130_fd_sc_hd__mux2_1
X_2281_ net374 _0945_ _0915_ VGND VGND VPWR VPWR _0946_ sky130_fd_sc_hd__mux2_1
XPHY_EDGE_ROW_63_Left_156 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkbuf_leaf_1_clk clknet_3_0__leaf_clk VGND VGND VPWR VPWR clknet_leaf_1_clk sky130_fd_sc_hd__clkbuf_8
X_4020_ clknet_leaf_10_clk _0060_ VGND VGND VPWR VPWR instance_2.data\[2\]\[60\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_63_801 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_87_541 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_35_536 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_74_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_59_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_72_Left_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_51_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3804_ _1861_ VGND VGND VPWR VPWR _0646_ sky130_fd_sc_hd__clkbuf_1
X_1996_ _0748_ VGND VGND VPWR VPWR net92 sky130_fd_sc_hd__buf_1
XFILLER_0_62_408 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3735_ _1825_ VGND VGND VPWR VPWR _0613_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_15_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_70_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3666_ _1789_ VGND VGND VPWR VPWR _0580_ sky130_fd_sc_hd__clkbuf_1
X_2617_ net41 _1205_ _1199_ VGND VGND VPWR VPWR _1206_ sky130_fd_sc_hd__mux2_1
XFILLER_0_11_541 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_2_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_62_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3597_ _0961_ net817 _1748_ VGND VGND VPWR VPWR _1753_ sky130_fd_sc_hd__mux2_1
XPHY_EDGE_ROW_81_Left_174 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2548_ _1152_ VGND VGND VPWR VPWR _0099_ sky130_fd_sc_hd__clkbuf_1
X_2479_ _1099_ VGND VGND VPWR VPWR _0083_ sky130_fd_sc_hd__clkbuf_1
X_4218_ clknet_leaf_23_clk _0258_ VGND VGND VPWR VPWR instance_2.data\[0\]\[42\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_87_1022 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4149_ clknet_leaf_21_clk _0189_ VGND VGND VPWR VPWR instance_2.data\[1\]\[45\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_92_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_38_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_90_Left_183 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_65_202 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_80_216 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_53_408 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_73_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_46_493 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_6_261 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_3_Left_96 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_88_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_69_530 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_29_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_84_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_32_506 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_71_249 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_516 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_21_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3520_ _1712_ VGND VGND VPWR VPWR _0511_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_40_583 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xhold718 instance_1.rdata\[12\] VGND VGND VPWR VPWR net868 sky130_fd_sc_hd__dlygate4sd3_1
Xhold707 instance_2.data\[1\]\[15\] VGND VGND VPWR VPWR net857 sky130_fd_sc_hd__dlygate4sd3_1
X_3451_ _1676_ VGND VGND VPWR VPWR _0478_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_12_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3382_ _1640_ VGND VGND VPWR VPWR _0445_ sky130_fd_sc_hd__clkbuf_1
X_2402_ _1038_ net67 _1012_ VGND VGND VPWR VPWR _1039_ sky130_fd_sc_hd__mux2_1
X_2333_ _0985_ net50 _0978_ VGND VGND VPWR VPWR _0986_ sky130_fd_sc_hd__mux2_1
X_2264_ _0932_ VGND VGND VPWR VPWR _0035_ sky130_fd_sc_hd__clkbuf_1
X_2195_ instance_2.data\[0\]\[20\] instance_2.data\[1\]\[20\] instance_2.data\[2\]\[20\]
+ instance_2.data\[3\]\[20\] _0855_ _0868_ VGND VGND VPWR VPWR _0879_ sky130_fd_sc_hd__mux4_1
X_4003_ clknet_leaf_22_clk _0043_ VGND VGND VPWR VPWR instance_2.data\[2\]\[43\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_87_382 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_47_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_90_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_28_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1979_ _0739_ VGND VGND VPWR VPWR net83 sky130_fd_sc_hd__buf_1
XFILLER_0_15_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3718_ _1816_ VGND VGND VPWR VPWR _0605_ sky130_fd_sc_hd__clkbuf_1
X_3649_ _1044_ net679 _1770_ VGND VGND VPWR VPWR _1780_ sky130_fd_sc_hd__mux2_1
XFILLER_0_87_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold12 instance_1.data\[1\]\[49\] VGND VGND VPWR VPWR net162 sky130_fd_sc_hd__dlygate4sd3_1
Xhold23 instance_2.data\[3\]\[70\] VGND VGND VPWR VPWR net173 sky130_fd_sc_hd__dlygate4sd3_1
Xhold56 instance_1.rdata\[9\] VGND VGND VPWR VPWR net206 sky130_fd_sc_hd__dlygate4sd3_1
Xhold34 instance_1.data\[0\]\[18\] VGND VGND VPWR VPWR net184 sky130_fd_sc_hd__dlygate4sd3_1
Xhold45 instance_2.data\[3\]\[23\] VGND VGND VPWR VPWR net195 sky130_fd_sc_hd__dlygate4sd3_1
Xhold78 instance_1.data\[0\]\[48\] VGND VGND VPWR VPWR net228 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_74_907 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xhold89 instance_1.data\[2\]\[33\] VGND VGND VPWR VPWR net239 sky130_fd_sc_hd__dlygate4sd3_1
Xhold67 instance_2.data\[3\]\[11\] VGND VGND VPWR VPWR net217 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_3_231 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_78_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_66_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_26_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_21_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_67_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_83_28 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_45_631 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2951_ _0900_ net377 _1406_ VGND VGND VPWR VPWR _1413_ sky130_fd_sc_hd__mux2_1
XFILLER_0_32_32 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4621_ clknet_leaf_48_clk _0661_ VGND VGND VPWR VPWR instance_2.data\[3\]\[13\] sky130_fd_sc_hd__dfxtp_1
X_2882_ net659 _1036_ _1369_ VGND VGND VPWR VPWR _1376_ sky130_fd_sc_hd__mux2_1
X_4552_ clknet_leaf_44_clk _0592_ VGND VGND VPWR VPWR instance_1.data\[0\]\[16\] sky130_fd_sc_hd__dfxtp_1
Xhold504 instance_2.data\[1\]\[4\] VGND VGND VPWR VPWR net654 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_12_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold526 instance_1.data\[3\]\[2\] VGND VGND VPWR VPWR net676 sky130_fd_sc_hd__dlygate4sd3_1
Xhold515 instance_1.data\[1\]\[11\] VGND VGND VPWR VPWR net665 sky130_fd_sc_hd__dlygate4sd3_1
X_4483_ clknet_leaf_51_clk _0523_ VGND VGND VPWR VPWR instance_2.rdata\[19\] sky130_fd_sc_hd__dfxtp_1
X_3503_ _1703_ VGND VGND VPWR VPWR _0503_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_40_433 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3434_ _1667_ VGND VGND VPWR VPWR _0470_ sky130_fd_sc_hd__clkbuf_1
Xhold537 instance_2.data\[1\]\[10\] VGND VGND VPWR VPWR net687 sky130_fd_sc_hd__dlygate4sd3_1
Xhold559 instance_1.data\[2\]\[60\] VGND VGND VPWR VPWR net709 sky130_fd_sc_hd__dlygate4sd3_1
Xhold548 instance_2.data\[0\]\[50\] VGND VGND VPWR VPWR net698 sky130_fd_sc_hd__dlygate4sd3_1
X_3365_ _1631_ VGND VGND VPWR VPWR _0437_ sky130_fd_sc_hd__clkbuf_1
X_3296_ net486 _1212_ _1589_ VGND VGND VPWR VPWR _1595_ sky130_fd_sc_hd__mux2_1
XFILLER_0_57_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2316_ net631 _0972_ _0949_ VGND VGND VPWR VPWR _0973_ sky130_fd_sc_hd__mux2_1
X_2247_ _0919_ VGND VGND VPWR VPWR _0031_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_0_201 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_25_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2178_ _0865_ net11 _0842_ VGND VGND VPWR VPWR _0866_ sky130_fd_sc_hd__mux2_1
XFILLER_0_67_308 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_48_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_35_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_90_377 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_31_422 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xoutput79 net79 VGND VGND VPWR VPWR rdata[11] sky130_fd_sc_hd__clkbuf_4
XTAP_TAPCELL_ROW_59_756 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_19_Right_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_39_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_39_544 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_42_601 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_336 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_81_399 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_22_400 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_3_1__f_clk clknet_0_clk VGND VGND VPWR VPWR clknet_3_1__leaf_clk sky130_fd_sc_hd__clkbuf_16
XFILLER_0_34_282 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_22_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_28_Right_28 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3150_ net224 _1222_ _1509_ VGND VGND VPWR VPWR _1518_ sky130_fd_sc_hd__mux2_1
X_3081_ net221 _1111_ _1476_ VGND VGND VPWR VPWR _1482_ sky130_fd_sc_hd__mux2_1
X_2101_ instance_2.data\[0\]\[0\] instance_2.data\[1\]\[0\] instance_2.data\[2\]\[0\]
+ instance_2.data\[3\]\[0\] _0802_ _0804_ VGND VGND VPWR VPWR _0805_ sky130_fd_sc_hd__mux4_1
X_2032_ _0767_ VGND VGND VPWR VPWR net111 sky130_fd_sc_hd__buf_1
XPHY_EDGE_ROW_37_Right_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_43_31 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_9_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3983_ clknet_leaf_38_clk _0023_ VGND VGND VPWR VPWR instance_2.data\[2\]\[23\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_43_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2934_ _0873_ net480 _1395_ VGND VGND VPWR VPWR _1404_ sky130_fd_sc_hd__mux2_1
X_2865_ net438 _1009_ _1358_ VGND VGND VPWR VPWR _1367_ sky130_fd_sc_hd__mux2_1
X_4604_ clknet_leaf_4_clk _0644_ VGND VGND VPWR VPWR instance_1.data\[0\]\[68\] sky130_fd_sc_hd__dfxtp_1
XPHY_EDGE_ROW_46_Right_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_25_271 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4535_ clknet_leaf_54_clk _0575_ VGND VGND VPWR VPWR instance_2.rdata\[71\] sky130_fd_sc_hd__dfxtp_1
X_2796_ net307 _0897_ _1325_ VGND VGND VPWR VPWR _1331_ sky130_fd_sc_hd__mux2_1
Xhold301 instance_2.rdata\[51\] VGND VGND VPWR VPWR net451 sky130_fd_sc_hd__dlygate4sd3_1
Xhold312 instance_1.data\[3\]\[55\] VGND VGND VPWR VPWR net462 sky130_fd_sc_hd__dlygate4sd3_1
Xhold334 instance_1.data\[0\]\[16\] VGND VGND VPWR VPWR net484 sky130_fd_sc_hd__dlygate4sd3_1
Xhold323 instance_2.data\[2\]\[69\] VGND VGND VPWR VPWR net473 sky130_fd_sc_hd__dlygate4sd3_1
Xhold356 instance_1.rdata\[58\] VGND VGND VPWR VPWR net506 sky130_fd_sc_hd__dlygate4sd3_1
X_4466_ clknet_leaf_60_clk _0506_ VGND VGND VPWR VPWR instance_2.rdata\[2\] sky130_fd_sc_hd__dfxtp_1
Xhold345 instance_2.data\[3\]\[14\] VGND VGND VPWR VPWR net495 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_7_86 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xhold367 instance_1.data\[0\]\[20\] VGND VGND VPWR VPWR net517 sky130_fd_sc_hd__dlygate4sd3_1
Xhold378 instance_2.data\[0\]\[51\] VGND VGND VPWR VPWR net528 sky130_fd_sc_hd__dlygate4sd3_1
X_4397_ clknet_leaf_55_clk _0437_ VGND VGND VPWR VPWR instance_1.data\[2\]\[5\] sky130_fd_sc_hd__dfxtp_1
X_3417_ net306 _1161_ _1658_ VGND VGND VPWR VPWR _1659_ sky130_fd_sc_hd__mux2_1
Xhold389 instance_2.data\[1\]\[51\] VGND VGND VPWR VPWR net539 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_68_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_90_1051 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3348_ net249 _1294_ _1544_ VGND VGND VPWR VPWR _1622_ sky130_fd_sc_hd__mux2_1
X_3279_ net370 _1184_ _1578_ VGND VGND VPWR VPWR _1586_ sky130_fd_sc_hd__mux2_1
XPHY_EDGE_ROW_55_Right_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_90_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_75_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_11_306 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_64_Right_64 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_51_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_73_Right_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_27_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_82_Right_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_73_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_6_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_89_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2650_ _1231_ VGND VGND VPWR VPWR _0122_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_42_528 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2581_ instance_1.data\[0\]\[35\] instance_1.data\[1\]\[35\] instance_1.data\[2\]\[35\]
+ instance_1.data\[3\]\[35\] _1177_ _1156_ VGND VGND VPWR VPWR _1178_ sky130_fd_sc_hd__mux4_1
XFILLER_0_10_425 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4320_ clknet_leaf_0_clk _0360_ VGND VGND VPWR VPWR instance_1.rdata\[0\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_10_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4251_ clknet_leaf_61_clk _0291_ VGND VGND VPWR VPWR instance_1.data\[3\]\[3\] sky130_fd_sc_hd__dfxtp_1
XPHY_EDGE_ROW_91_Right_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3202_ net229 _1055_ _1545_ VGND VGND VPWR VPWR _1546_ sky130_fd_sc_hd__mux2_1
X_4182_ clknet_leaf_59_clk _0222_ VGND VGND VPWR VPWR instance_2.data\[0\]\[6\] sky130_fd_sc_hd__dfxtp_1
X_3133_ _1464_ VGND VGND VPWR VPWR _1509_ sky130_fd_sc_hd__buf_4
X_3064_ net205 _1083_ _1465_ VGND VGND VPWR VPWR _1473_ sky130_fd_sc_hd__mux2_1
XFILLER_0_54_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2015_ _0758_ VGND VGND VPWR VPWR net102 sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_53_707 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_77_458 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3966_ clknet_leaf_59_clk _0006_ VGND VGND VPWR VPWR instance_2.data\[2\]\[6\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_72_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2917_ _1383_ VGND VGND VPWR VPWR _1395_ sky130_fd_sc_hd__buf_4
XFILLER_0_92_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_72_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_33_528 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3897_ _1911_ VGND VGND VPWR VPWR _0689_ sky130_fd_sc_hd__clkbuf_1
X_2848_ _1302_ VGND VGND VPWR VPWR _1358_ sky130_fd_sc_hd__buf_4
X_2779_ net211 _0870_ _1314_ VGND VGND VPWR VPWR _1322_ sky130_fd_sc_hd__mux2_1
Xhold153 instance_2.data\[2\]\[12\] VGND VGND VPWR VPWR net303 sky130_fd_sc_hd__dlygate4sd3_1
Xhold120 instance_1.data\[3\]\[24\] VGND VGND VPWR VPWR net270 sky130_fd_sc_hd__dlygate4sd3_1
Xhold142 instance_1.rdata\[24\] VGND VGND VPWR VPWR net292 sky130_fd_sc_hd__dlygate4sd3_1
Xhold131 instance_2.data\[3\]\[50\] VGND VGND VPWR VPWR net281 sky130_fd_sc_hd__dlygate4sd3_1
X_4518_ clknet_leaf_13_clk _0558_ VGND VGND VPWR VPWR instance_2.rdata\[54\] sky130_fd_sc_hd__dfxtp_1
X_4449_ clknet_leaf_14_clk _0489_ VGND VGND VPWR VPWR instance_1.data\[2\]\[57\] sky130_fd_sc_hd__dfxtp_1
Xhold164 instance_1.data\[2\]\[57\] VGND VGND VPWR VPWR net314 sky130_fd_sc_hd__dlygate4sd3_1
Xhold175 instance_1.data\[2\]\[13\] VGND VGND VPWR VPWR net325 sky130_fd_sc_hd__dlygate4sd3_1
Xhold186 instance_1.data\[2\]\[25\] VGND VGND VPWR VPWR net336 sky130_fd_sc_hd__dlygate4sd3_1
Xhold197 instance_1.data\[0\]\[32\] VGND VGND VPWR VPWR net347 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_69_851 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_24_431 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_55_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_36_322 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_48_182 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_91_461 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_91_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3820_ net240 _0829_ _1865_ VGND VGND VPWR VPWR _1871_ sky130_fd_sc_hd__mux2_1
X_3751_ net428 _1213_ _1828_ VGND VGND VPWR VPWR _1834_ sky130_fd_sc_hd__mux2_1
XFILLER_0_39_182 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_15_517 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_6_227 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2702_ net545 _1271_ _1264_ VGND VGND VPWR VPWR _1272_ sky130_fd_sc_hd__mux2_1
XFILLER_0_54_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3682_ net609 _1101_ _1795_ VGND VGND VPWR VPWR _1798_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_30_489 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2633_ instance_1.data\[0\]\[47\] instance_1.data\[1\]\[47\] instance_1.data\[2\]\[47\]
+ instance_1.data\[3\]\[47\] _1211_ _1190_ VGND VGND VPWR VPWR _1218_ sky130_fd_sc_hd__mux4_1
XFILLER_0_30_509 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_433 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_2_455 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2564_ _1045_ VGND VGND VPWR VPWR _1165_ sky130_fd_sc_hd__buf_4
X_4303_ clknet_leaf_15_clk _0343_ VGND VGND VPWR VPWR instance_1.data\[3\]\[55\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_2_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2495_ net730 _1111_ _1094_ VGND VGND VPWR VPWR _1112_ sky130_fd_sc_hd__mux2_1
XFILLER_0_10_299 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4234_ clknet_leaf_11_clk _0274_ VGND VGND VPWR VPWR instance_2.data\[0\]\[58\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_4_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4165_ clknet_leaf_2_clk _0205_ VGND VGND VPWR VPWR instance_2.data\[1\]\[61\] sky130_fd_sc_hd__dfxtp_1
X_3116_ _1500_ VGND VGND VPWR VPWR _0319_ sky130_fd_sc_hd__clkbuf_1
X_4096_ clknet_leaf_3_clk _0136_ VGND VGND VPWR VPWR instance_1.data\[1\]\[64\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_38_556 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3047_ _1058_ _0809_ _0808_ VGND VGND VPWR VPWR _1463_ sky130_fd_sc_hd__and3b_1
XFILLER_0_92_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_81_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_21_401 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3949_ _1938_ VGND VGND VPWR VPWR _0714_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_18_399 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_41_380 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_56_406 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_83_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_83_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_72_879 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_56_439 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_36_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_51_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_20_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_9_281 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_19_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2280_ _0943_ net36 _0944_ VGND VGND VPWR VPWR _0945_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_63_802 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_59_255 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_47_406 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_7_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3803_ net713 _1295_ net150 VGND VGND VPWR VPWR _1861_ sky130_fd_sc_hd__mux2_1
X_1995_ instance_1.rdata\[23\] instance_2.rdata\[23\] _0744_ VGND VGND VPWR VPWR _0748_
+ sky130_fd_sc_hd__mux2_1
X_3734_ net297 _1185_ _1817_ VGND VGND VPWR VPWR _1825_ sky130_fd_sc_hd__mux2_1
X_3665_ net505 _1073_ _1784_ VGND VGND VPWR VPWR _1789_ sky130_fd_sc_hd__mux2_1
X_2616_ instance_1.data\[0\]\[43\] instance_1.data\[1\]\[43\] instance_1.data\[2\]\[43\]
+ instance_1.data\[3\]\[43\] _1177_ _1190_ VGND VGND VPWR VPWR _1205_ sky130_fd_sc_hd__mux4_1
XFILLER_0_70_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3596_ _1752_ VGND VGND VPWR VPWR _0547_ sky130_fd_sc_hd__clkbuf_1
X_2547_ net161 _1151_ _1128_ VGND VGND VPWR VPWR _1152_ sky130_fd_sc_hd__mux2_1
X_2478_ net665 _1098_ _1094_ VGND VGND VPWR VPWR _1099_ sky130_fd_sc_hd__mux2_1
XFILLER_0_55_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4217_ clknet_leaf_23_clk _0257_ VGND VGND VPWR VPWR instance_2.data\[0\]\[41\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_87_1023 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4148_ clknet_leaf_21_clk _0188_ VGND VGND VPWR VPWR instance_2.data\[1\]\[44\] sky130_fd_sc_hd__dfxtp_1
X_4079_ clknet_leaf_18_clk _0119_ VGND VGND VPWR VPWR instance_1.data\[1\]\[47\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_65_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_18_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_80_228 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_33_155 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_61_475 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_77_927 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_84_545 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_32_507 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_37_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_71_239 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_4_528 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_40_584 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xhold719 instance_2.rdata\[9\] VGND VGND VPWR VPWR net869 sky130_fd_sc_hd__dlygate4sd3_1
Xhold708 instance_2.rdata\[20\] VGND VGND VPWR VPWR net858 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_52_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_52_486 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3450_ net212 _1216_ _1669_ VGND VGND VPWR VPWR _1676_ sky130_fd_sc_hd__mux2_1
X_3381_ net325 _1104_ _1636_ VGND VGND VPWR VPWR _1640_ sky130_fd_sc_hd__mux2_1
X_2401_ instance_2.data\[0\]\[67\] instance_2.data\[1\]\[67\] instance_2.data\[2\]\[67\]
+ instance_2.data\[3\]\[67\] _1025_ _0809_ VGND VGND VPWR VPWR _1038_ sky130_fd_sc_hd__mux4_1
X_2332_ instance_2.data\[0\]\[51\] instance_2.data\[1\]\[51\] instance_2.data\[2\]\[51\]
+ instance_2.data\[3\]\[51\] _0957_ _0970_ VGND VGND VPWR VPWR _0985_ sky130_fd_sc_hd__mux4_1
X_4002_ clknet_leaf_23_clk _0042_ VGND VGND VPWR VPWR instance_2.data\[2\]\[42\] sky130_fd_sc_hd__dfxtp_1
X_2263_ net220 _0931_ _0915_ VGND VGND VPWR VPWR _0932_ sky130_fd_sc_hd__mux2_1
X_2194_ _0878_ VGND VGND VPWR VPWR _0019_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_48_651 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_1_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_75_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_47_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1978_ instance_1.rdata\[15\] instance_2.rdata\[15\] _0733_ VGND VGND VPWR VPWR _0739_
+ sky130_fd_sc_hd__mux2_1
X_3717_ net277 _1158_ _1806_ VGND VGND VPWR VPWR _1816_ sky130_fd_sc_hd__mux2_1
X_3648_ _1779_ VGND VGND VPWR VPWR _0572_ sky130_fd_sc_hd__clkbuf_1
X_3579_ _1743_ VGND VGND VPWR VPWR _0539_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_87_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold13 instance_2.data\[2\]\[36\] VGND VGND VPWR VPWR net163 sky130_fd_sc_hd__dlygate4sd3_1
Xhold46 instance_1.data\[2\]\[43\] VGND VGND VPWR VPWR net196 sky130_fd_sc_hd__dlygate4sd3_1
Xhold35 instance_1.data\[1\]\[52\] VGND VGND VPWR VPWR net185 sky130_fd_sc_hd__dlygate4sd3_1
Xhold24 instance_1.data\[1\]\[0\] VGND VGND VPWR VPWR net174 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_3_232 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xhold79 instance_1.rdata\[0\] VGND VGND VPWR VPWR net229 sky130_fd_sc_hd__dlygate4sd3_1
Xhold57 instance_1.data\[0\]\[65\] VGND VGND VPWR VPWR net207 sky130_fd_sc_hd__dlygate4sd3_1
Xhold68 instance_1.rdata\[68\] VGND VGND VPWR VPWR net218 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_82_974 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_81_515 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_46_280 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_34_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_34_486 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_21_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_57_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_29_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2950_ _1412_ VGND VGND VPWR VPWR _0241_ sky130_fd_sc_hd__clkbuf_1
X_2881_ _1375_ VGND VGND VPWR VPWR _0209_ sky130_fd_sc_hd__clkbuf_1
X_4620_ clknet_leaf_49_clk _0660_ VGND VGND VPWR VPWR instance_2.data\[3\]\[12\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_25_431 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_25_453 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_4_347 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4551_ clknet_leaf_43_clk _0591_ VGND VGND VPWR VPWR instance_1.data\[0\]\[15\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_52_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_4_369 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4482_ clknet_leaf_47_clk _0522_ VGND VGND VPWR VPWR instance_2.rdata\[18\] sky130_fd_sc_hd__dfxtp_1
X_3502_ net701 _1298_ net149 VGND VGND VPWR VPWR _1703_ sky130_fd_sc_hd__mux2_1
Xhold516 instance_1.data\[3\]\[29\] VGND VGND VPWR VPWR net666 sky130_fd_sc_hd__dlygate4sd3_1
Xhold505 instance_2.rdata\[39\] VGND VGND VPWR VPWR net655 sky130_fd_sc_hd__dlygate4sd3_1
Xhold527 instance_2.rdata\[50\] VGND VGND VPWR VPWR net677 sky130_fd_sc_hd__dlygate4sd3_1
Xhold549 instance_1.data\[1\]\[36\] VGND VGND VPWR VPWR net699 sky130_fd_sc_hd__dlygate4sd3_1
X_3433_ net379 _1188_ _1658_ VGND VGND VPWR VPWR _1667_ sky130_fd_sc_hd__mux2_1
XFILLER_0_12_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xhold538 instance_1.data\[0\]\[31\] VGND VGND VPWR VPWR net688 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_40_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3364_ net260 _1077_ _1625_ VGND VGND VPWR VPWR _1631_ sky130_fd_sc_hd__mux2_1
X_3295_ _1594_ VGND VGND VPWR VPWR _0404_ sky130_fd_sc_hd__clkbuf_1
X_2315_ _0971_ net45 _0944_ VGND VGND VPWR VPWR _0972_ sky130_fd_sc_hd__mux2_1
X_2246_ net762 _0918_ _0915_ VGND VGND VPWR VPWR _0919_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_0_202 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2177_ instance_2.data\[0\]\[16\] instance_2.data\[1\]\[16\] instance_2.data\[2\]\[16\]
+ instance_2.data\[3\]\[16\] _0855_ _0834_ VGND VGND VPWR VPWR _0865_ sky130_fd_sc_hd__mux4_1
XFILLER_0_18_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_79_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_87_180 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_48_545 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_7_152 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_90_389 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_59_757 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_58_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_42_602 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_337 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_81_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_22_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_27_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3080_ _1481_ VGND VGND VPWR VPWR _0302_ sky130_fd_sc_hd__clkbuf_1
X_2100_ _0803_ VGND VGND VPWR VPWR _0804_ sky130_fd_sc_hd__buf_4
X_2031_ instance_1.rdata\[40\] instance_2.rdata\[40\] _0766_ VGND VGND VPWR VPWR _0767_
+ sky130_fd_sc_hd__mux2_1
X_3982_ clknet_leaf_52_clk _0022_ VGND VGND VPWR VPWR instance_2.data\[2\]\[22\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_43_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2933_ _1403_ VGND VGND VPWR VPWR _0233_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_84_183 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2864_ _1366_ VGND VGND VPWR VPWR _0201_ sky130_fd_sc_hd__clkbuf_1
X_4603_ clknet_leaf_54_clk _0643_ VGND VGND VPWR VPWR instance_1.data\[0\]\[67\] sky130_fd_sc_hd__dfxtp_1
X_2795_ _1330_ VGND VGND VPWR VPWR _0168_ sky130_fd_sc_hd__clkbuf_1
X_4534_ clknet_leaf_53_clk _0574_ VGND VGND VPWR VPWR instance_2.rdata\[70\] sky130_fd_sc_hd__dfxtp_1
Xhold302 instance_2.data\[2\]\[53\] VGND VGND VPWR VPWR net452 sky130_fd_sc_hd__dlygate4sd3_1
Xhold313 instance_1.rdata\[1\] VGND VGND VPWR VPWR net463 sky130_fd_sc_hd__dlygate4sd3_1
Xhold324 instance_1.data\[0\]\[2\] VGND VGND VPWR VPWR net474 sky130_fd_sc_hd__dlygate4sd3_1
Xhold335 instance_2.data\[1\]\[41\] VGND VGND VPWR VPWR net485 sky130_fd_sc_hd__dlygate4sd3_1
X_4465_ clknet_leaf_60_clk _0505_ VGND VGND VPWR VPWR instance_2.rdata\[1\] sky130_fd_sc_hd__dfxtp_1
Xhold346 instance_2.rdata\[14\] VGND VGND VPWR VPWR net496 sky130_fd_sc_hd__dlygate4sd3_1
Xhold368 instance_1.data\[3\]\[6\] VGND VGND VPWR VPWR net518 sky130_fd_sc_hd__dlygate4sd3_1
Xhold357 instance_2.data\[2\]\[66\] VGND VGND VPWR VPWR net507 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_68_62 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold379 instance_1.data\[1\]\[46\] VGND VGND VPWR VPWR net529 sky130_fd_sc_hd__dlygate4sd3_1
X_4396_ clknet_leaf_58_clk _0436_ VGND VGND VPWR VPWR instance_1.data\[2\]\[4\] sky130_fd_sc_hd__dfxtp_1
X_3416_ _1624_ VGND VGND VPWR VPWR _1658_ sky130_fd_sc_hd__buf_4
XTAP_TAPCELL_ROW_90_1052 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3347_ _1621_ VGND VGND VPWR VPWR _0429_ sky130_fd_sc_hd__clkbuf_1
X_3278_ _1585_ VGND VGND VPWR VPWR _0396_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_84_94 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2229_ _0905_ VGND VGND VPWR VPWR _0027_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_56_727 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_63_312 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_11_307 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_63_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_90_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_51_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_90_197 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_73_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_13_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_39_375 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_89_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2580_ _0801_ VGND VGND VPWR VPWR _1177_ sky130_fd_sc_hd__buf_4
X_4250_ clknet_leaf_61_clk _0290_ VGND VGND VPWR VPWR instance_1.data\[3\]\[2\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_1_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4181_ clknet_leaf_55_clk _0221_ VGND VGND VPWR VPWR instance_2.data\[0\]\[5\] sky130_fd_sc_hd__dfxtp_1
X_3201_ _1544_ VGND VGND VPWR VPWR _1545_ sky130_fd_sc_hd__buf_4
X_3132_ _1508_ VGND VGND VPWR VPWR _0327_ sky130_fd_sc_hd__clkbuf_1
X_3063_ _1472_ VGND VGND VPWR VPWR _0294_ sky130_fd_sc_hd__clkbuf_1
X_2014_ instance_1.rdata\[32\] instance_2.rdata\[32\] _0755_ VGND VGND VPWR VPWR _0758_
+ sky130_fd_sc_hd__mux2_1
XFILLER_0_85_481 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3965_ clknet_leaf_4_clk _0005_ VGND VGND VPWR VPWR instance_2.data\[2\]\[5\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_57_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_70_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2916_ _1394_ VGND VGND VPWR VPWR _0225_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_45_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3896_ net736 _0952_ _1909_ VGND VGND VPWR VPWR _1911_ sky130_fd_sc_hd__mux2_1
XFILLER_0_45_378 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2847_ _1357_ VGND VGND VPWR VPWR _0193_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_85_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2778_ _1321_ VGND VGND VPWR VPWR _0160_ sky130_fd_sc_hd__clkbuf_1
Xhold110 instance_1.data\[2\]\[5\] VGND VGND VPWR VPWR net260 sky130_fd_sc_hd__dlygate4sd3_1
Xhold121 instance_2.data\[1\]\[28\] VGND VGND VPWR VPWR net271 sky130_fd_sc_hd__dlygate4sd3_1
Xhold132 instance_2.data\[0\]\[49\] VGND VGND VPWR VPWR net282 sky130_fd_sc_hd__dlygate4sd3_1
Xhold143 instance_2.data\[1\]\[52\] VGND VGND VPWR VPWR net293 sky130_fd_sc_hd__dlygate4sd3_1
X_4517_ clknet_leaf_13_clk _0557_ VGND VGND VPWR VPWR instance_2.rdata\[53\] sky130_fd_sc_hd__dfxtp_1
Xhold176 instance_1.data\[1\]\[39\] VGND VGND VPWR VPWR net326 sky130_fd_sc_hd__dlygate4sd3_1
X_4448_ clknet_leaf_14_clk _0488_ VGND VGND VPWR VPWR instance_1.data\[2\]\[56\] sky130_fd_sc_hd__dfxtp_1
Xhold165 instance_1.rdata\[65\] VGND VGND VPWR VPWR net315 sky130_fd_sc_hd__dlygate4sd3_1
Xhold154 instance_2.data\[3\]\[37\] VGND VGND VPWR VPWR net304 sky130_fd_sc_hd__dlygate4sd3_1
Xhold187 instance_2.data\[3\]\[61\] VGND VGND VPWR VPWR net337 sky130_fd_sc_hd__dlygate4sd3_1
Xhold198 instance_2.data\[1\]\[48\] VGND VGND VPWR VPWR net348 sky130_fd_sc_hd__dlygate4sd3_1
X_4379_ clknet_leaf_13_clk _0419_ VGND VGND VPWR VPWR instance_1.rdata\[59\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_69_852 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_68_459 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_24_432 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_48_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_76_481 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_91_473 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_63_142 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3750_ _1833_ VGND VGND VPWR VPWR _0620_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_82_440 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_27_367 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2701_ net62 _1270_ _1267_ VGND VGND VPWR VPWR _1271_ sky130_fd_sc_hd__mux2_1
XFILLER_0_15_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3681_ _1797_ VGND VGND VPWR VPWR _0587_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_40_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2632_ _1217_ VGND VGND VPWR VPWR _0118_ sky130_fd_sc_hd__clkbuf_1
X_2563_ instance_1.data\[0\]\[31\] instance_1.data\[1\]\[31\] instance_1.data\[2\]\[31\]
+ instance_1.data\[3\]\[31\] _1143_ _1156_ VGND VGND VPWR VPWR _1164_ sky130_fd_sc_hd__mux4_1
X_4302_ clknet_leaf_15_clk _0342_ VGND VGND VPWR VPWR instance_1.data\[3\]\[54\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_49_42 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2494_ net10 _1110_ _1097_ VGND VGND VPWR VPWR _1111_ sky130_fd_sc_hd__mux2_1
X_4233_ clknet_leaf_11_clk _0273_ VGND VGND VPWR VPWR instance_2.data\[0\]\[57\] sky130_fd_sc_hd__dfxtp_1
X_4164_ clknet_leaf_9_clk _0204_ VGND VGND VPWR VPWR instance_2.data\[1\]\[60\] sky130_fd_sc_hd__dfxtp_1
X_4095_ clknet_leaf_1_clk _0135_ VGND VGND VPWR VPWR instance_1.data\[1\]\[63\] sky130_fd_sc_hd__dfxtp_1
X_3115_ net500 _1166_ _1498_ VGND VGND VPWR VPWR _1500_ sky130_fd_sc_hd__mux2_1
X_3046_ _1462_ VGND VGND VPWR VPWR _0287_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_66_822 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_38_557 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_81_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_77_234 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_77_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_37_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_92_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_21_402 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3948_ net316 _1036_ _1931_ VGND VGND VPWR VPWR _1938_ sky130_fd_sc_hd__mux2_1
X_3879_ net718 _0925_ _1898_ VGND VGND VPWR VPWR _1902_ sky130_fd_sc_hd__mux2_1
XFILLER_0_14_551 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_41_370 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_68_212 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_68_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_91_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_86_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_32_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_9_282 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_19_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_47_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_74_226 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3802_ _1860_ VGND VGND VPWR VPWR _0645_ sky130_fd_sc_hd__clkbuf_1
X_1994_ _0747_ VGND VGND VPWR VPWR net91 sky130_fd_sc_hd__buf_1
X_3733_ _1824_ VGND VGND VPWR VPWR _0612_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_70_454 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3664_ _1788_ VGND VGND VPWR VPWR _0579_ sky130_fd_sc_hd__clkbuf_1
X_2615_ _1204_ VGND VGND VPWR VPWR _0114_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_70_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_2_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3595_ _0958_ net813 _1748_ VGND VGND VPWR VPWR _1752_ sky130_fd_sc_hd__mux2_1
X_2546_ net23 _1150_ _1131_ VGND VGND VPWR VPWR _1151_ sky130_fd_sc_hd__mux2_1
XFILLER_0_76_40 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2477_ net6 _1096_ _1097_ VGND VGND VPWR VPWR _1098_ sky130_fd_sc_hd__mux2_1
X_4216_ clknet_leaf_37_clk _0256_ VGND VGND VPWR VPWR instance_2.data\[0\]\[40\] sky130_fd_sc_hd__dfxtp_1
X_4147_ clknet_leaf_22_clk _0187_ VGND VGND VPWR VPWR instance_2.data\[1\]\[43\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_87_1024 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4078_ clknet_leaf_18_clk _0118_ VGND VGND VPWR VPWR instance_1.data\[1\]\[46\] sky130_fd_sc_hd__dfxtp_1
X_3029_ _1027_ net798 _1450_ VGND VGND VPWR VPWR _1454_ sky130_fd_sc_hd__mux2_1
XFILLER_0_38_418 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_33_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_33_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_61_498 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_6_252 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_77_928 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_32_508 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_21_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_12_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_12_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold709 instance_2.data\[0\]\[0\] VGND VGND VPWR VPWR net859 sky130_fd_sc_hd__dlygate4sd3_1
X_2400_ _1037_ VGND VGND VPWR VPWR _0066_ sky130_fd_sc_hd__clkbuf_1
X_3380_ _1639_ VGND VGND VPWR VPWR _0444_ sky130_fd_sc_hd__clkbuf_1
X_2331_ _0984_ VGND VGND VPWR VPWR _0050_ sky130_fd_sc_hd__clkbuf_1
X_2262_ _0930_ net32 _0910_ VGND VGND VPWR VPWR _0931_ sky130_fd_sc_hd__mux2_1
X_4001_ clknet_leaf_23_clk _0041_ VGND VGND VPWR VPWR instance_2.data\[2\]\[41\] sky130_fd_sc_hd__dfxtp_1
X_2193_ net674 _0877_ _0847_ VGND VGND VPWR VPWR _0878_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_48_652 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_87_362 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_62_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1977_ _0738_ VGND VGND VPWR VPWR net82 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_7_367 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3716_ _1815_ VGND VGND VPWR VPWR _0604_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_3_551 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3647_ _1041_ net680 _1770_ VGND VGND VPWR VPWR _1779_ sky130_fd_sc_hd__mux2_1
X_3578_ _0930_ net481 _1737_ VGND VGND VPWR VPWR _1743_ sky130_fd_sc_hd__mux2_1
X_2529_ net19 _1137_ _1131_ VGND VGND VPWR VPWR _1138_ sky130_fd_sc_hd__mux2_1
Xhold14 instance_2.data\[1\]\[70\] VGND VGND VPWR VPWR net164 sky130_fd_sc_hd__dlygate4sd3_1
Xhold36 instance_1.data\[3\]\[43\] VGND VGND VPWR VPWR net186 sky130_fd_sc_hd__dlygate4sd3_1
Xhold25 instance_1.data\[0\]\[27\] VGND VGND VPWR VPWR net175 sky130_fd_sc_hd__dlygate4sd3_1
Xhold47 instance_2.data\[1\]\[59\] VGND VGND VPWR VPWR net197 sky130_fd_sc_hd__dlygate4sd3_1
Xhold58 instance_1.data\[2\]\[39\] VGND VGND VPWR VPWR net208 sky130_fd_sc_hd__dlygate4sd3_1
Xhold69 instance_1.data\[0\]\[22\] VGND VGND VPWR VPWR net219 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_82_975 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_81_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_17_357 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_84_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2880_ net250 _1033_ _1369_ VGND VGND VPWR VPWR _1375_ sky130_fd_sc_hd__mux2_1
XFILLER_0_44_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_37_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4550_ clknet_leaf_45_clk _0590_ VGND VGND VPWR VPWR instance_1.data\[0\]\[14\] sky130_fd_sc_hd__dfxtp_1
X_4481_ clknet_leaf_43_clk _0521_ VGND VGND VPWR VPWR instance_2.rdata\[17\] sky130_fd_sc_hd__dfxtp_1
Xhold517 instance_1.data\[2\]\[69\] VGND VGND VPWR VPWR net667 sky130_fd_sc_hd__dlygate4sd3_1
X_3501_ _1702_ VGND VGND VPWR VPWR _0502_ sky130_fd_sc_hd__clkbuf_1
Xhold506 instance_2.rdata\[52\] VGND VGND VPWR VPWR net656 sky130_fd_sc_hd__dlygate4sd3_1
X_3432_ _1666_ VGND VGND VPWR VPWR _0469_ sky130_fd_sc_hd__clkbuf_1
Xhold528 instance_2.rdata\[36\] VGND VGND VPWR VPWR net678 sky130_fd_sc_hd__dlygate4sd3_1
Xhold539 instance_2.data\[3\]\[30\] VGND VGND VPWR VPWR net689 sky130_fd_sc_hd__dlygate4sd3_1
X_3363_ _1630_ VGND VGND VPWR VPWR _0436_ sky130_fd_sc_hd__clkbuf_1
X_3294_ net765 _1208_ _1589_ VGND VGND VPWR VPWR _1594_ sky130_fd_sc_hd__mux2_1
X_2314_ instance_2.data\[0\]\[47\] instance_2.data\[1\]\[47\] instance_2.data\[2\]\[47\]
+ instance_2.data\[3\]\[47\] _0957_ _0970_ VGND VGND VPWR VPWR _0971_ sky130_fd_sc_hd__mux4_1
XFILLER_0_32_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2245_ _0917_ net28 _0910_ VGND VGND VPWR VPWR _0918_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_0_203 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2176_ _0864_ VGND VGND VPWR VPWR _0015_ sky130_fd_sc_hd__clkbuf_1
XPHY_EDGE_ROW_69_Left_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_48_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_87_192 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_63_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xclkbuf_leaf_60_clk clknet_3_0__leaf_clk VGND VGND VPWR VPWR clknet_leaf_60_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_0_90_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_78_Left_171 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_16_454 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4679_ clknet_leaf_54_clk _0719_ VGND VGND VPWR VPWR instance_2.data\[3\]\[71\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_43_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_1_Right_1 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_11_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_87_Left_180 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_59_758 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_42_603 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_leaf_51_clk clknet_3_4__leaf_clk VGND VGND VPWR VPWR clknet_leaf_51_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_0_54_549 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_27_78 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2030_ _0721_ VGND VGND VPWR VPWR _0766_ sky130_fd_sc_hd__clkbuf_4
X_3981_ clknet_leaf_52_clk _0021_ VGND VGND VPWR VPWR instance_2.data\[2\]\[21\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_43_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2932_ _0870_ net803 _1395_ VGND VGND VPWR VPWR _1403_ sky130_fd_sc_hd__mux2_1
Xclkbuf_leaf_42_clk clknet_3_5__leaf_clk VGND VGND VPWR VPWR clknet_leaf_42_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_0_45_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_84_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_17_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2863_ net355 _1006_ _1358_ VGND VGND VPWR VPWR _1366_ sky130_fd_sc_hd__mux2_1
X_4602_ clknet_leaf_3_clk _0642_ VGND VGND VPWR VPWR instance_1.data\[0\]\[66\] sky130_fd_sc_hd__dfxtp_1
X_2794_ net237 _0894_ _1325_ VGND VGND VPWR VPWR _1330_ sky130_fd_sc_hd__mux2_1
X_4533_ clknet_leaf_5_clk _0573_ VGND VGND VPWR VPWR instance_2.rdata\[69\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_13_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xhold325 instance_2.data\[2\]\[71\] VGND VGND VPWR VPWR net475 sky130_fd_sc_hd__dlygate4sd3_1
Xhold314 instance_1.rdata\[69\] VGND VGND VPWR VPWR net464 sky130_fd_sc_hd__dlygate4sd3_1
Xhold303 instance_2.data\[1\]\[49\] VGND VGND VPWR VPWR net453 sky130_fd_sc_hd__dlygate4sd3_1
Xhold347 instance_1.data\[3\]\[57\] VGND VGND VPWR VPWR net497 sky130_fd_sc_hd__dlygate4sd3_1
Xhold336 instance_1.rdata\[45\] VGND VGND VPWR VPWR net486 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_7_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold358 instance_1.rdata\[18\] VGND VGND VPWR VPWR net508 sky130_fd_sc_hd__dlygate4sd3_1
X_4464_ clknet_leaf_0_clk _0504_ VGND VGND VPWR VPWR instance_2.rdata\[0\] sky130_fd_sc_hd__dfxtp_1
Xhold369 instance_1.data\[0\]\[33\] VGND VGND VPWR VPWR net519 sky130_fd_sc_hd__dlygate4sd3_1
X_4395_ clknet_leaf_61_clk _0435_ VGND VGND VPWR VPWR instance_1.data\[2\]\[3\] sky130_fd_sc_hd__dfxtp_1
X_3415_ _1657_ VGND VGND VPWR VPWR _0461_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_68_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_90_1053 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3346_ net464 _1291_ _1611_ VGND VGND VPWR VPWR _1621_ sky130_fd_sc_hd__mux2_1
X_3277_ net352 _1181_ _1578_ VGND VGND VPWR VPWR _1585_ sky130_fd_sc_hd__mux2_1
XFILLER_0_30_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2228_ net159 _0904_ _0881_ VGND VGND VPWR VPWR _0905_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_56_728 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2159_ _0851_ VGND VGND VPWR VPWR _0011_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_36_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_48_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkbuf_leaf_33_clk clknet_3_7__leaf_clk VGND VGND VPWR VPWR clknet_leaf_33_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_0_90_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_11_308 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_90_165 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_27_452 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_39_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkbuf_leaf_24_clk clknet_3_6__leaf_clk VGND VGND VPWR VPWR clknet_leaf_24_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_0_27_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_27_549 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4180_ clknet_leaf_58_clk _0220_ VGND VGND VPWR VPWR instance_2.data\[0\]\[4\] sky130_fd_sc_hd__dfxtp_1
X_3200_ _1058_ VGND VGND VPWR VPWR _1544_ sky130_fd_sc_hd__clkbuf_8
X_3131_ net273 _1192_ _1498_ VGND VGND VPWR VPWR _1508_ sky130_fd_sc_hd__mux2_1
XFILLER_0_38_99 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3062_ net518 _1080_ _1465_ VGND VGND VPWR VPWR _1472_ sky130_fd_sc_hd__mux2_1
XFILLER_0_54_32 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2013_ _0757_ VGND VGND VPWR VPWR net101 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_92_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_leaf_15_clk clknet_3_2__leaf_clk VGND VGND VPWR VPWR clknet_leaf_15_clk sky130_fd_sc_hd__clkbuf_8
X_3964_ clknet_leaf_59_clk _0004_ VGND VGND VPWR VPWR instance_2.data\[2\]\[4\] sky130_fd_sc_hd__dfxtp_1
X_2915_ _0843_ net727 _1384_ VGND VGND VPWR VPWR _1394_ sky130_fd_sc_hd__mux2_1
X_3895_ _1910_ VGND VGND VPWR VPWR _0688_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_61_775 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_70_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_5_410 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2846_ net453 _0979_ _1347_ VGND VGND VPWR VPWR _1357_ sky130_fd_sc_hd__mux2_1
X_2777_ net415 _0866_ _1314_ VGND VGND VPWR VPWR _1321_ sky130_fd_sc_hd__mux2_1
XFILLER_0_5_487 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_41_541 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xhold100 instance_2.data\[1\]\[65\] VGND VGND VPWR VPWR net250 sky130_fd_sc_hd__dlygate4sd3_1
Xhold133 instance_1.data\[3\]\[44\] VGND VGND VPWR VPWR net283 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_79_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xhold122 instance_1.data\[1\]\[24\] VGND VGND VPWR VPWR net272 sky130_fd_sc_hd__dlygate4sd3_1
Xhold111 instance_1.rdata\[25\] VGND VGND VPWR VPWR net261 sky130_fd_sc_hd__dlygate4sd3_1
Xhold144 instance_1.rdata\[26\] VGND VGND VPWR VPWR net294 sky130_fd_sc_hd__dlygate4sd3_1
X_4516_ clknet_leaf_20_clk _0556_ VGND VGND VPWR VPWR instance_2.rdata\[52\] sky130_fd_sc_hd__dfxtp_1
X_4447_ clknet_leaf_15_clk _0487_ VGND VGND VPWR VPWR instance_1.data\[2\]\[55\] sky130_fd_sc_hd__dfxtp_1
Xhold166 instance_2.data\[3\]\[66\] VGND VGND VPWR VPWR net316 sky130_fd_sc_hd__dlygate4sd3_1
Xhold177 instance_2.data\[3\]\[56\] VGND VGND VPWR VPWR net327 sky130_fd_sc_hd__dlygate4sd3_1
Xhold155 instance_2.data\[2\]\[41\] VGND VGND VPWR VPWR net305 sky130_fd_sc_hd__dlygate4sd3_1
Xhold199 instance_1.data\[1\]\[19\] VGND VGND VPWR VPWR net349 sky130_fd_sc_hd__dlygate4sd3_1
Xhold188 instance_2.data\[2\]\[64\] VGND VGND VPWR VPWR net338 sky130_fd_sc_hd__dlygate4sd3_1
X_4378_ clknet_leaf_13_clk _0418_ VGND VGND VPWR VPWR instance_1.rdata\[58\] sky130_fd_sc_hd__dfxtp_1
X_3329_ _1612_ VGND VGND VPWR VPWR _0420_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_69_853 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_76_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_91_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_36_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_91_485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2700_ instance_1.data\[0\]\[62\] instance_1.data\[1\]\[62\] instance_1.data\[2\]\[62\]
+ instance_1.data\[3\]\[62\] _1245_ _1258_ VGND VGND VPWR VPWR _1270_ sky130_fd_sc_hd__mux4_1
XFILLER_0_82_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3680_ net490 _1098_ _1795_ VGND VGND VPWR VPWR _1797_ sky130_fd_sc_hd__mux2_1
XFILLER_0_27_379 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2631_ net529 _1216_ _1196_ VGND VGND VPWR VPWR _1217_ sky130_fd_sc_hd__mux2_1
XFILLER_0_23_541 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2562_ _1163_ VGND VGND VPWR VPWR _0102_ sky130_fd_sc_hd__clkbuf_1
X_4301_ clknet_leaf_15_clk _0341_ VGND VGND VPWR VPWR instance_1.data\[3\]\[53\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_64_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2493_ instance_1.data\[0\]\[15\] instance_1.data\[1\]\[15\] instance_1.data\[2\]\[15\]
+ instance_1.data\[3\]\[15\] _1109_ _1088_ VGND VGND VPWR VPWR _1110_ sky130_fd_sc_hd__mux4_1
X_4232_ clknet_leaf_12_clk _0272_ VGND VGND VPWR VPWR instance_2.data\[0\]\[56\] sky130_fd_sc_hd__dfxtp_1
Xclkbuf_leaf_4_clk clknet_3_1__leaf_clk VGND VGND VPWR VPWR clknet_leaf_4_clk sky130_fd_sc_hd__clkbuf_8
X_4163_ clknet_leaf_10_clk _0203_ VGND VGND VPWR VPWR instance_2.data\[1\]\[59\] sky130_fd_sc_hd__dfxtp_1
X_4094_ clknet_leaf_1_clk _0134_ VGND VGND VPWR VPWR instance_1.data\[1\]\[62\] sky130_fd_sc_hd__dfxtp_1
X_3114_ _1499_ VGND VGND VPWR VPWR _0318_ sky130_fd_sc_hd__clkbuf_1
X_3045_ _1052_ net770 _1383_ VGND VGND VPWR VPWR _1462_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_66_823 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_38_558 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_18_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_21_403 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3947_ _1937_ VGND VGND VPWR VPWR _0713_ sky130_fd_sc_hd__clkbuf_1
X_3878_ _1901_ VGND VGND VPWR VPWR _0680_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_14_530 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2829_ _1348_ VGND VGND VPWR VPWR _0184_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_60_168 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_41_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_14_Left_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_91_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_23_Left_116 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_20_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_9_283 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_19_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_32_Left_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkbuf_3_7__f_clk clknet_0_clk VGND VGND VPWR VPWR clknet_3_7__leaf_clk sky130_fd_sc_hd__clkbuf_16
XTAP_TAPCELL_ROW_35_528 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_74_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_71_870 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3801_ net625 _1292_ _1850_ VGND VGND VPWR VPWR _1860_ sky130_fd_sc_hd__mux2_1
XFILLER_0_27_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1993_ instance_1.rdata\[22\] instance_2.rdata\[22\] _0744_ VGND VGND VPWR VPWR _0747_
+ sky130_fd_sc_hd__mux2_1
XFILLER_0_51_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3732_ net468 _1182_ _1817_ VGND VGND VPWR VPWR _1824_ sky130_fd_sc_hd__mux2_1
XFILLER_0_82_271 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_42_102 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_82_282 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3663_ net279 _1070_ _1784_ VGND VGND VPWR VPWR _1788_ sky130_fd_sc_hd__mux2_1
XPHY_EDGE_ROW_41_Left_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2614_ net312 _1203_ _1196_ VGND VGND VPWR VPWR _1204_ sky130_fd_sc_hd__mux2_1
X_3594_ _1751_ VGND VGND VPWR VPWR _0546_ sky130_fd_sc_hd__clkbuf_1
X_2545_ instance_1.data\[0\]\[27\] instance_1.data\[1\]\[27\] instance_1.data\[2\]\[27\]
+ instance_1.data\[3\]\[27\] _1143_ _1122_ VGND VGND VPWR VPWR _1150_ sky130_fd_sc_hd__mux4_1
X_2476_ _1045_ VGND VGND VPWR VPWR _1097_ sky130_fd_sc_hd__buf_4
X_4215_ clknet_leaf_36_clk _0255_ VGND VGND VPWR VPWR instance_2.data\[0\]\[39\] sky130_fd_sc_hd__dfxtp_1
XPHY_EDGE_ROW_50_Left_143 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4146_ clknet_leaf_23_clk _0186_ VGND VGND VPWR VPWR instance_2.data\[1\]\[42\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_87_1025 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4077_ clknet_leaf_19_clk _0117_ VGND VGND VPWR VPWR instance_1.data\[1\]\[45\] sky130_fd_sc_hd__dfxtp_1
X_3028_ _1453_ VGND VGND VPWR VPWR _0278_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_58_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_33_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_371 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_6_253 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_77_929 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_49_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_21_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_40_575 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_20_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2330_ net541 _0982_ _0983_ VGND VGND VPWR VPWR _0984_ sky130_fd_sc_hd__mux2_1
X_2261_ instance_2.data\[0\]\[35\] instance_2.data\[1\]\[35\] instance_2.data\[2\]\[35\]
+ instance_2.data\[3\]\[35\] _0923_ _0902_ VGND VGND VPWR VPWR _0930_ sky130_fd_sc_hd__mux4_1
X_4000_ clknet_leaf_22_clk _0040_ VGND VGND VPWR VPWR instance_2.data\[2\]\[40\] sky130_fd_sc_hd__dfxtp_1
X_2192_ _0875_ net14 _0876_ VGND VGND VPWR VPWR _0877_ sky130_fd_sc_hd__mux2_1
XFILLER_0_46_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_48_653 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_62_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_75_514 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_1_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_87_396 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_87_374 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1976_ instance_1.rdata\[14\] instance_2.rdata\[14\] _0733_ VGND VGND VPWR VPWR _0738_
+ sky130_fd_sc_hd__mux2_1
XFILLER_0_7_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_28_485 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_62_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3715_ net635 _1154_ _1806_ VGND VGND VPWR VPWR _1815_ sky130_fd_sc_hd__mux2_1
XFILLER_0_15_146 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_43_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3646_ _1778_ VGND VGND VPWR VPWR _0571_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_70_274 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_87_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3577_ _1742_ VGND VGND VPWR VPWR _0538_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_60_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2528_ instance_1.data\[0\]\[23\] instance_1.data\[1\]\[23\] instance_1.data\[2\]\[23\]
+ instance_1.data\[3\]\[23\] _1109_ _1122_ VGND VGND VPWR VPWR _1137_ sky130_fd_sc_hd__mux4_1
Xhold15 instance_1.data\[3\]\[49\] VGND VGND VPWR VPWR net165 sky130_fd_sc_hd__dlygate4sd3_1
Xhold37 instance_1.data\[1\]\[2\] VGND VGND VPWR VPWR net187 sky130_fd_sc_hd__dlygate4sd3_1
X_2459_ net783 _1083_ _1060_ VGND VGND VPWR VPWR _1084_ sky130_fd_sc_hd__mux2_1
Xhold26 instance_2.data\[1\]\[53\] VGND VGND VPWR VPWR net176 sky130_fd_sc_hd__dlygate4sd3_1
Xhold59 instance_1.rdata\[42\] VGND VGND VPWR VPWR net209 sky130_fd_sc_hd__dlygate4sd3_1
Xhold48 instance_1.data\[0\]\[5\] VGND VGND VPWR VPWR net198 sky130_fd_sc_hd__dlygate4sd3_1
X_4129_ clknet_leaf_53_clk _0169_ VGND VGND VPWR VPWR instance_2.data\[1\]\[25\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_82_976 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_34_400 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_34_444 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_45_623 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_17_358 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_4_327 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_25_466 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3500_ net799 _1295_ net149 VGND VGND VPWR VPWR _1702_ sky130_fd_sc_hd__mux2_1
XFILLER_0_52_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold507 instance_1.data\[0\]\[34\] VGND VGND VPWR VPWR net657 sky130_fd_sc_hd__dlygate4sd3_1
X_4480_ clknet_leaf_47_clk _0520_ VGND VGND VPWR VPWR instance_2.rdata\[16\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_12_127 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold518 instance_2.data\[0\]\[12\] VGND VGND VPWR VPWR net668 sky130_fd_sc_hd__dlygate4sd3_1
X_3431_ net213 _1185_ _1658_ VGND VGND VPWR VPWR _1666_ sky130_fd_sc_hd__mux2_1
Xhold529 instance_2.rdata\[69\] VGND VGND VPWR VPWR net679 sky130_fd_sc_hd__dlygate4sd3_1
X_3362_ net800 _1073_ _1625_ VGND VGND VPWR VPWR _1630_ sky130_fd_sc_hd__mux2_1
XFILLER_0_0_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2313_ net2 VGND VGND VPWR VPWR _0970_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_57_32 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3293_ _1593_ VGND VGND VPWR VPWR _0403_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_57_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2244_ instance_2.data\[0\]\[31\] instance_2.data\[1\]\[31\] instance_2.data\[2\]\[31\]
+ instance_2.data\[3\]\[31\] _0889_ _0902_ VGND VGND VPWR VPWR _0917_ sky130_fd_sc_hd__mux4_1
X_2175_ net761 _0863_ _0847_ VGND VGND VPWR VPWR _0864_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_0_204 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_73_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_48_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_71_550 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1959_ instance_1.rdata\[6\] instance_2.rdata\[6\] _0722_ VGND VGND VPWR VPWR _0729_
+ sky130_fd_sc_hd__mux2_1
X_4678_ clknet_leaf_6_clk _0718_ VGND VGND VPWR VPWR instance_2.data\[3\]\[70\] sky130_fd_sc_hd__dfxtp_1
X_3629_ _1769_ VGND VGND VPWR VPWR _0563_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_11_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_59_759 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_39_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_14_328 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_19_260 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_19_271 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_50_670 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_89_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3980_ clknet_leaf_52_clk _0020_ VGND VGND VPWR VPWR instance_2.data\[2\]\[20\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_69_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_84_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2931_ _1402_ VGND VGND VPWR VPWR _0232_ sky130_fd_sc_hd__clkbuf_1
Xclkbuf_0_clk clk VGND VGND VPWR VPWR clknet_0_clk sky130_fd_sc_hd__clkbuf_16
XFILLER_0_45_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4601_ clknet_leaf_4_clk _0641_ VGND VGND VPWR VPWR instance_1.data\[0\]\[65\] sky130_fd_sc_hd__dfxtp_1
X_2862_ _1365_ VGND VGND VPWR VPWR _0200_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_72_369 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2793_ _1329_ VGND VGND VPWR VPWR _0167_ sky130_fd_sc_hd__clkbuf_1
X_4532_ clknet_leaf_5_clk _0572_ VGND VGND VPWR VPWR instance_2.rdata\[68\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_40_200 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xhold326 instance_1.data\[3\]\[46\] VGND VGND VPWR VPWR net476 sky130_fd_sc_hd__dlygate4sd3_1
Xhold315 instance_2.data\[0\]\[3\] VGND VGND VPWR VPWR net465 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_13_458 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xhold304 instance_1.data\[3\]\[18\] VGND VGND VPWR VPWR net454 sky130_fd_sc_hd__dlygate4sd3_1
X_4463_ clknet_leaf_54_clk _0503_ VGND VGND VPWR VPWR instance_1.data\[2\]\[71\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_40_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xhold359 instance_2.rdata\[37\] VGND VGND VPWR VPWR net509 sky130_fd_sc_hd__dlygate4sd3_1
Xhold337 instance_1.data\[0\]\[6\] VGND VGND VPWR VPWR net487 sky130_fd_sc_hd__dlygate4sd3_1
Xhold348 instance_2.data\[1\]\[8\] VGND VGND VPWR VPWR net498 sky130_fd_sc_hd__dlygate4sd3_1
X_3414_ net590 _1158_ _1647_ VGND VGND VPWR VPWR _1657_ sky130_fd_sc_hd__mux2_1
XPHY_EDGE_ROW_15_Right_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4394_ clknet_leaf_61_clk _0434_ VGND VGND VPWR VPWR instance_1.data\[2\]\[2\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_40_288 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_90_1054 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3345_ _1620_ VGND VGND VPWR VPWR _0428_ sky130_fd_sc_hd__clkbuf_1
X_3276_ _1584_ VGND VGND VPWR VPWR _0395_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_84_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2227_ _0903_ net23 _0876_ VGND VGND VPWR VPWR _0904_ sky130_fd_sc_hd__mux2_1
XFILLER_0_23_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_56_729 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2158_ net280 _0850_ _0847_ VGND VGND VPWR VPWR _0851_ sky130_fd_sc_hd__mux2_1
XPHY_EDGE_ROW_24_Right_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2089_ instance_1.rdata\[68\] instance_2.rdata\[68\] _0788_ VGND VGND VPWR VPWR _0797_
+ sky130_fd_sc_hd__mux2_1
XFILLER_0_8_430 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_36_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_75_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_63_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_90_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_90_177 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_33_Right_33 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_42_Right_42 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_27_453 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_13_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_27_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_39_355 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_66_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_51_Right_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3130_ _1507_ VGND VGND VPWR VPWR _0326_ sky130_fd_sc_hd__clkbuf_1
X_3061_ _1471_ VGND VGND VPWR VPWR _0293_ sky130_fd_sc_hd__clkbuf_1
XPHY_EDGE_ROW_60_Right_60 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_89_255 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_54_44 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2012_ instance_1.rdata\[31\] instance_2.rdata\[31\] _0755_ VGND VGND VPWR VPWR _0757_
+ sky130_fd_sc_hd__mux2_1
X_3963_ clknet_leaf_60_clk _0003_ VGND VGND VPWR VPWR instance_2.data\[2\]\[3\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_70_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2914_ _1393_ VGND VGND VPWR VPWR _0224_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_57_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3894_ net748 _0948_ _1909_ VGND VGND VPWR VPWR _1910_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_61_776 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2845_ _1356_ VGND VGND VPWR VPWR _0192_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_72_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_5_444 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_60_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4515_ clknet_leaf_16_clk _0555_ VGND VGND VPWR VPWR instance_2.rdata\[51\] sky130_fd_sc_hd__dfxtp_1
X_2776_ _1320_ VGND VGND VPWR VPWR _0159_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_13_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_5_499 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_5_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xhold101 instance_1.data\[3\]\[28\] VGND VGND VPWR VPWR net251 sky130_fd_sc_hd__dlygate4sd3_1
Xhold123 instance_1.data\[3\]\[39\] VGND VGND VPWR VPWR net273 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_13_255 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xhold112 instance_1.data\[2\]\[21\] VGND VGND VPWR VPWR net262 sky130_fd_sc_hd__dlygate4sd3_1
Xhold134 instance_1.data\[1\]\[28\] VGND VGND VPWR VPWR net284 sky130_fd_sc_hd__dlygate4sd3_1
X_4446_ clknet_leaf_15_clk _0486_ VGND VGND VPWR VPWR instance_1.data\[2\]\[54\] sky130_fd_sc_hd__dfxtp_1
Xhold167 instance_1.data\[1\]\[21\] VGND VGND VPWR VPWR net317 sky130_fd_sc_hd__dlygate4sd3_1
Xhold145 instance_2.data\[0\]\[69\] VGND VGND VPWR VPWR net295 sky130_fd_sc_hd__dlygate4sd3_1
Xhold156 instance_1.data\[2\]\[30\] VGND VGND VPWR VPWR net306 sky130_fd_sc_hd__dlygate4sd3_1
Xhold178 instance_1.data\[1\]\[41\] VGND VGND VPWR VPWR net328 sky130_fd_sc_hd__dlygate4sd3_1
X_4377_ clknet_leaf_13_clk _0417_ VGND VGND VPWR VPWR instance_1.rdata\[57\] sky130_fd_sc_hd__dfxtp_1
Xhold189 instance_1.data\[1\]\[26\] VGND VGND VPWR VPWR net339 sky130_fd_sc_hd__dlygate4sd3_1
X_3328_ net334 _1262_ _1611_ VGND VGND VPWR VPWR _1612_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_69_854 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3259_ _1575_ VGND VGND VPWR VPWR _0387_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_24_423 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_48_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_91_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xhold690 instance_2.rdata\[66\] VGND VGND VPWR VPWR net840 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_59_406 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_86_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_39_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_82_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2630_ net44 _1215_ _1199_ VGND VGND VPWR VPWR _1216_ sky130_fd_sc_hd__mux2_1
XFILLER_0_42_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_54_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2561_ net248 _1161_ _1162_ VGND VGND VPWR VPWR _1163_ sky130_fd_sc_hd__mux2_1
X_4300_ clknet_leaf_16_clk _0340_ VGND VGND VPWR VPWR instance_1.data\[3\]\[52\] sky130_fd_sc_hd__dfxtp_1
X_2492_ _0801_ VGND VGND VPWR VPWR _1109_ sky130_fd_sc_hd__buf_4
XFILLER_0_49_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4231_ clknet_leaf_12_clk _0271_ VGND VGND VPWR VPWR instance_2.data\[0\]\[55\] sky130_fd_sc_hd__dfxtp_1
X_4162_ clknet_leaf_11_clk _0202_ VGND VGND VPWR VPWR instance_2.data\[1\]\[58\] sky130_fd_sc_hd__dfxtp_1
X_4093_ clknet_leaf_1_clk _0133_ VGND VGND VPWR VPWR instance_1.data\[1\]\[61\] sky130_fd_sc_hd__dfxtp_1
X_3113_ net399 _1161_ _1498_ VGND VGND VPWR VPWR _1499_ sky130_fd_sc_hd__mux2_1
X_3044_ _1461_ VGND VGND VPWR VPWR _0286_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_66_824 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_77_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_38_559 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_92_206 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_45_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3946_ net741 _1033_ _1931_ VGND VGND VPWR VPWR _1937_ sky130_fd_sc_hd__mux2_1
XFILLER_0_90_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_60_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3877_ net425 _0921_ _1898_ VGND VGND VPWR VPWR _1901_ sky130_fd_sc_hd__mux2_1
X_2828_ net192 _0948_ _1347_ VGND VGND VPWR VPWR _1348_ sky130_fd_sc_hd__mux2_1
X_2759_ _1311_ VGND VGND VPWR VPWR _0151_ sky130_fd_sc_hd__clkbuf_1
X_4429_ clknet_leaf_28_clk _0469_ VGND VGND VPWR VPWR instance_1.data\[2\]\[37\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_24_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_10_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_20_545 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_9_284 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_35_529 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_59_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3800_ _1859_ VGND VGND VPWR VPWR _0644_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_51_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3731_ _1823_ VGND VGND VPWR VPWR _0611_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_71_871 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1992_ _0746_ VGND VGND VPWR VPWR net90 sky130_fd_sc_hd__buf_1
XFILLER_0_82_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_27_155 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_82_294 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_70_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3662_ _1787_ VGND VGND VPWR VPWR _0578_ sky130_fd_sc_hd__clkbuf_1
X_2613_ net40 _1202_ _1199_ VGND VGND VPWR VPWR _1203_ sky130_fd_sc_hd__mux2_1
X_3593_ _0954_ net796 _1748_ VGND VGND VPWR VPWR _1751_ sky130_fd_sc_hd__mux2_1
XFILLER_0_11_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2544_ _1149_ VGND VGND VPWR VPWR _0098_ sky130_fd_sc_hd__clkbuf_1
X_2475_ instance_1.data\[0\]\[11\] instance_1.data\[1\]\[11\] instance_1.data\[2\]\[11\]
+ instance_1.data\[3\]\[11\] _1075_ _1088_ VGND VGND VPWR VPWR _1096_ sky130_fd_sc_hd__mux4_1
X_4214_ clknet_leaf_28_clk _0254_ VGND VGND VPWR VPWR instance_2.data\[0\]\[38\] sky130_fd_sc_hd__dfxtp_1
X_4145_ clknet_leaf_23_clk _0185_ VGND VGND VPWR VPWR instance_2.data\[1\]\[41\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_92_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_87_1026 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4076_ clknet_leaf_26_clk _0116_ VGND VGND VPWR VPWR instance_1.data\[1\]\[44\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_92_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3027_ _1023_ net744 _1450_ VGND VGND VPWR VPWR _1453_ sky130_fd_sc_hd__mux2_1
XFILLER_0_73_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_46_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3929_ net712 _1006_ _1920_ VGND VGND VPWR VPWR _1928_ sky130_fd_sc_hd__mux2_1
XFILLER_0_33_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_14_383 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_6_254 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_88_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_69_534 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_21_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_52_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_24_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_24_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_40_576 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_64_294 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2260_ _0929_ VGND VGND VPWR VPWR _0034_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_20_397 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2191_ _0720_ VGND VGND VPWR VPWR _0876_ sky130_fd_sc_hd__buf_4
XTAP_TAPCELL_ROW_48_654 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_1_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_75_537 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_47_239 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1975_ _0737_ VGND VGND VPWR VPWR net81 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_28_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_28_497 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3714_ _1814_ VGND VGND VPWR VPWR _0603_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_15_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_70_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3645_ _1038_ net641 _1770_ VGND VGND VPWR VPWR _1778_ sky130_fd_sc_hd__mux2_1
XFILLER_0_70_286 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3576_ _0927_ net825 _1737_ VGND VGND VPWR VPWR _1742_ sky130_fd_sc_hd__mux2_1
XFILLER_0_11_320 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2527_ _1136_ VGND VGND VPWR VPWR _0094_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_11_386 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2458_ net73 _1082_ _1063_ VGND VGND VPWR VPWR _1083_ sky130_fd_sc_hd__mux2_1
XPHY_EDGE_ROW_89_Right_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold27 instance_2.data\[2\]\[37\] VGND VGND VPWR VPWR net177 sky130_fd_sc_hd__dlygate4sd3_1
Xhold38 instance_1.data\[1\]\[66\] VGND VGND VPWR VPWR net188 sky130_fd_sc_hd__dlygate4sd3_1
Xhold16 instance_1.data\[1\]\[23\] VGND VGND VPWR VPWR net166 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_3_224 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xhold49 instance_1.data\[2\]\[1\] VGND VGND VPWR VPWR net199 sky130_fd_sc_hd__dlygate4sd3_1
X_2389_ instance_2.data\[0\]\[64\] instance_2.data\[1\]\[64\] instance_2.data\[2\]\[64\]
+ instance_2.data\[3\]\[64\] _1025_ _1004_ VGND VGND VPWR VPWR _1029_ sky130_fd_sc_hd__mux4_1
X_4128_ clknet_leaf_53_clk _0168_ VGND VGND VPWR VPWR instance_2.data\[1\]\[24\] sky130_fd_sc_hd__dfxtp_1
X_4059_ clknet_leaf_34_clk _0099_ VGND VGND VPWR VPWR instance_1.data\[1\]\[27\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_82_977 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_38_206 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_38_239 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_19_464 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_34_412 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_16_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_88_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_45_624 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_17_359 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_69_375 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_32_14 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_32_47 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_37_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_52_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold508 instance_1.data\[2\]\[35\] VGND VGND VPWR VPWR net658 sky130_fd_sc_hd__dlygate4sd3_1
X_3430_ _1665_ VGND VGND VPWR VPWR _0468_ sky130_fd_sc_hd__clkbuf_1
Xhold519 instance_2.data\[1\]\[29\] VGND VGND VPWR VPWR net669 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_0_545 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3361_ _1629_ VGND VGND VPWR VPWR _0435_ sky130_fd_sc_hd__clkbuf_1
X_2312_ _0969_ VGND VGND VPWR VPWR _0046_ sky130_fd_sc_hd__clkbuf_1
X_3292_ net650 _1205_ _1589_ VGND VGND VPWR VPWR _1593_ sky130_fd_sc_hd__mux2_1
X_2243_ _0916_ VGND VGND VPWR VPWR _0030_ sky130_fd_sc_hd__clkbuf_1
X_2174_ _0862_ net10 _0842_ VGND VGND VPWR VPWR _0863_ sky130_fd_sc_hd__mux2_1
XFILLER_0_75_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_75_345 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_75_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1958_ _0728_ VGND VGND VPWR VPWR net132 sky130_fd_sc_hd__buf_1
X_4677_ clknet_leaf_7_clk _0717_ VGND VGND VPWR VPWR instance_2.data\[3\]\[69\] sky130_fd_sc_hd__dfxtp_1
X_3628_ _1011_ net867 _1759_ VGND VGND VPWR VPWR _1769_ sky130_fd_sc_hd__mux2_1
X_3559_ _0899_ net717 _1726_ VGND VGND VPWR VPWR _1733_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_14_329 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_81_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_50_671 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_57_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2930_ _0866_ net546 _1395_ VGND VGND VPWR VPWR _1402_ sky130_fd_sc_hd__mux2_1
XFILLER_0_43_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_84_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_84_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4600_ clknet_leaf_3_clk _0640_ VGND VGND VPWR VPWR instance_1.data\[0\]\[64\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_45_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2861_ net202 _1002_ _1358_ VGND VGND VPWR VPWR _1365_ sky130_fd_sc_hd__mux2_1
XFILLER_0_57_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_25_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2792_ net380 _0891_ _1325_ VGND VGND VPWR VPWR _1329_ sky130_fd_sc_hd__mux2_1
X_4531_ clknet_leaf_5_clk _0571_ VGND VGND VPWR VPWR instance_2.rdata\[67\] sky130_fd_sc_hd__dfxtp_1
Xhold305 instance_2.data\[0\]\[13\] VGND VGND VPWR VPWR net455 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_25_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4462_ clknet_leaf_54_clk _0502_ VGND VGND VPWR VPWR instance_1.data\[2\]\[70\] sky130_fd_sc_hd__dfxtp_1
Xhold316 instance_1.data\[3\]\[32\] VGND VGND VPWR VPWR net466 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_68_10 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold338 instance_1.data\[1\]\[59\] VGND VGND VPWR VPWR net488 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_7_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_40_256 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold349 instance_1.data\[2\]\[24\] VGND VGND VPWR VPWR net499 sky130_fd_sc_hd__dlygate4sd3_1
X_3413_ _1656_ VGND VGND VPWR VPWR _0460_ sky130_fd_sc_hd__clkbuf_1
Xhold327 instance_2.data\[2\]\[43\] VGND VGND VPWR VPWR net477 sky130_fd_sc_hd__dlygate4sd3_1
X_4393_ clknet_leaf_61_clk _0433_ VGND VGND VPWR VPWR instance_1.data\[2\]\[1\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_90_1055 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3344_ net218 _1288_ _1611_ VGND VGND VPWR VPWR _1620_ sky130_fd_sc_hd__mux2_1
X_3275_ net255 _1178_ _1578_ VGND VGND VPWR VPWR _1584_ sky130_fd_sc_hd__mux2_1
X_2226_ instance_2.data\[0\]\[27\] instance_2.data\[1\]\[27\] instance_2.data\[2\]\[27\]
+ instance_2.data\[3\]\[27\] _0889_ _0902_ VGND VGND VPWR VPWR _0903_ sky130_fd_sc_hd__mux4_1
XFILLER_0_16_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2157_ _0849_ net6 _0842_ VGND VGND VPWR VPWR _0850_ sky130_fd_sc_hd__mux2_1
X_2088_ _0796_ VGND VGND VPWR VPWR net140 sky130_fd_sc_hd__buf_1
XFILLER_0_67_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_63_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_75_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_8_464 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_36_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_63_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_90_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_16_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_16_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_27_454 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_13_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_27_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_66_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_38_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_38_68 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3060_ net684 _1077_ _1465_ VGND VGND VPWR VPWR _1471_ sky130_fd_sc_hd__mux2_1
X_2011_ _0756_ VGND VGND VPWR VPWR net100 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_89_289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_85_440 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3962_ clknet_leaf_62_clk _0002_ VGND VGND VPWR VPWR instance_2.data\[2\]\[2\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_18_518 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_72_101 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2913_ _0839_ net711 _1384_ VGND VGND VPWR VPWR _1393_ sky130_fd_sc_hd__mux2_1
X_3893_ _1864_ VGND VGND VPWR VPWR _1909_ sky130_fd_sc_hd__buf_4
XTAP_TAPCELL_ROW_61_777 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2844_ net348 _0975_ _1347_ VGND VGND VPWR VPWR _1356_ sky130_fd_sc_hd__mux2_1
XFILLER_0_26_551 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_79_31 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2775_ net857 _0863_ _1314_ VGND VGND VPWR VPWR _1320_ sky130_fd_sc_hd__mux2_1
X_4514_ clknet_leaf_20_clk _0554_ VGND VGND VPWR VPWR instance_2.rdata\[50\] sky130_fd_sc_hd__dfxtp_1
Xhold135 instance_1.data\[2\]\[40\] VGND VGND VPWR VPWR net285 sky130_fd_sc_hd__dlygate4sd3_1
Xhold102 instance_2.data\[1\]\[38\] VGND VGND VPWR VPWR net252 sky130_fd_sc_hd__dlygate4sd3_1
Xhold113 instance_1.data\[1\]\[12\] VGND VGND VPWR VPWR net263 sky130_fd_sc_hd__dlygate4sd3_1
Xhold124 instance_1.data\[0\]\[1\] VGND VGND VPWR VPWR net274 sky130_fd_sc_hd__dlygate4sd3_1
X_4445_ clknet_leaf_15_clk _0485_ VGND VGND VPWR VPWR instance_1.data\[2\]\[53\] sky130_fd_sc_hd__dfxtp_1
Xhold146 instance_2.data\[3\]\[25\] VGND VGND VPWR VPWR net296 sky130_fd_sc_hd__dlygate4sd3_1
Xhold157 instance_2.data\[1\]\[25\] VGND VGND VPWR VPWR net307 sky130_fd_sc_hd__dlygate4sd3_1
Xhold168 instance_2.data\[3\]\[52\] VGND VGND VPWR VPWR net318 sky130_fd_sc_hd__dlygate4sd3_1
Xhold179 instance_1.data\[2\]\[51\] VGND VGND VPWR VPWR net329 sky130_fd_sc_hd__dlygate4sd3_1
X_4376_ clknet_leaf_13_clk _0416_ VGND VGND VPWR VPWR instance_1.rdata\[56\] sky130_fd_sc_hd__dfxtp_1
X_3327_ _1544_ VGND VGND VPWR VPWR _1611_ sky130_fd_sc_hd__clkbuf_4
X_3258_ net628 _1150_ _1567_ VGND VGND VPWR VPWR _1575_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_69_855 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3189_ _1538_ VGND VGND VPWR VPWR _0354_ sky130_fd_sc_hd__clkbuf_1
X_2209_ instance_2.data\[0\]\[23\] instance_2.data\[1\]\[23\] instance_2.data\[2\]\[23\]
+ instance_2.data\[3\]\[23\] _0889_ _0868_ VGND VGND VPWR VPWR _0890_ sky130_fd_sc_hd__mux4_1
XFILLER_0_68_418 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_48_120 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_24_424 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_48_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_48_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_5_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold680 instance_2.rdata\[61\] VGND VGND VPWR VPWR net830 sky130_fd_sc_hd__dlygate4sd3_1
Xhold691 instance_2.data\[0\]\[14\] VGND VGND VPWR VPWR net841 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_24_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_82_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_39_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_82_454 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_27_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_27_348 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_40_14 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2560_ _1059_ VGND VGND VPWR VPWR _1162_ sky130_fd_sc_hd__buf_4
XFILLER_0_2_459 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2491_ _1108_ VGND VGND VPWR VPWR _0086_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_49_67 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4230_ clknet_leaf_8_clk _0270_ VGND VGND VPWR VPWR instance_2.data\[0\]\[54\] sky130_fd_sc_hd__dfxtp_1
X_4161_ clknet_leaf_11_clk _0201_ VGND VGND VPWR VPWR instance_2.data\[1\]\[57\] sky130_fd_sc_hd__dfxtp_1
X_4092_ clknet_leaf_2_clk _0132_ VGND VGND VPWR VPWR instance_1.data\[1\]\[60\] sky130_fd_sc_hd__dfxtp_1
X_3112_ _1464_ VGND VGND VPWR VPWR _1498_ sky130_fd_sc_hd__buf_4
X_3043_ _1049_ net738 _1383_ VGND VGND VPWR VPWR _1461_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_66_825 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_92_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3945_ _1936_ VGND VGND VPWR VPWR _0712_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_85_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_45_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3876_ _1900_ VGND VGND VPWR VPWR _0679_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_83_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2827_ _1302_ VGND VGND VPWR VPWR _1347_ sky130_fd_sc_hd__buf_4
X_2758_ net567 _0836_ _1303_ VGND VGND VPWR VPWR _1311_ sky130_fd_sc_hd__mux2_1
X_4428_ clknet_leaf_30_clk _0468_ VGND VGND VPWR VPWR instance_1.data\[2\]\[36\] sky130_fd_sc_hd__dfxtp_1
X_2689_ _1261_ VGND VGND VPWR VPWR _0131_ sky130_fd_sc_hd__clkbuf_1
X_4359_ clknet_leaf_36_clk _0399_ VGND VGND VPWR VPWR instance_1.rdata\[39\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_64_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_9_285 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_19_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_59_259 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3730_ net705 _1179_ _1817_ VGND VGND VPWR VPWR _1823_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_71_872 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1991_ instance_1.rdata\[21\] instance_2.rdata\[21\] _0744_ VGND VGND VPWR VPWR _0746_
+ sky130_fd_sc_hd__mux2_1
XFILLER_0_51_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_27_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_55_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3661_ net474 _1067_ _1784_ VGND VGND VPWR VPWR _1787_ sky130_fd_sc_hd__mux2_1
XFILLER_0_42_126 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2612_ instance_1.data\[0\]\[42\] instance_1.data\[1\]\[42\] instance_1.data\[2\]\[42\]
+ instance_1.data\[3\]\[42\] _1177_ _1190_ VGND VGND VPWR VPWR _1202_ sky130_fd_sc_hd__mux4_1
X_3592_ _1750_ VGND VGND VPWR VPWR _0545_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_23_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2543_ net339 _1148_ _1128_ VGND VGND VPWR VPWR _1149_ sky130_fd_sc_hd__mux2_1
X_2474_ _1095_ VGND VGND VPWR VPWR _0082_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_48_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4213_ clknet_leaf_24_clk _0253_ VGND VGND VPWR VPWR instance_2.data\[0\]\[37\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_79_950 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4144_ clknet_leaf_22_clk _0184_ VGND VGND VPWR VPWR instance_2.data\[1\]\[40\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_92_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_87_1027 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4075_ clknet_leaf_26_clk _0115_ VGND VGND VPWR VPWR instance_1.data\[1\]\[43\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_92_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3026_ _1452_ VGND VGND VPWR VPWR _0277_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_18_112 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_46_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3928_ _1927_ VGND VGND VPWR VPWR _0704_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_6_551 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3859_ _1891_ VGND VGND VPWR VPWR _0671_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_61_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_6_255 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_84_527 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_21_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_37_476 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_37_487 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_40_577 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2190_ instance_2.data\[0\]\[19\] instance_2.data\[1\]\[19\] instance_2.data\[2\]\[19\]
+ instance_2.data\[3\]\[19\] _0855_ _0868_ VGND VGND VPWR VPWR _0875_ sky130_fd_sc_hd__mux4_1
XTAP_TAPCELL_ROW_76_920 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_1_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_48_655 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1974_ instance_1.rdata\[13\] instance_2.rdata\[13\] _0733_ VGND VGND VPWR VPWR _0737_
+ sky130_fd_sc_hd__mux2_1
XFILLER_0_7_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_28_454 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3713_ net175 _1151_ _1806_ VGND VGND VPWR VPWR _1814_ sky130_fd_sc_hd__mux2_1
XFILLER_0_3_521 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3644_ _1777_ VGND VGND VPWR VPWR _0570_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_11_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3575_ _1741_ VGND VGND VPWR VPWR _0537_ sky130_fd_sc_hd__clkbuf_1
X_2526_ net607 _1135_ _1128_ VGND VGND VPWR VPWR _1136_ sky130_fd_sc_hd__mux2_1
X_2457_ instance_1.data\[0\]\[7\] instance_1.data\[1\]\[7\] instance_1.data\[2\]\[7\]
+ instance_1.data\[3\]\[7\] _1075_ _1054_ VGND VGND VPWR VPWR _1082_ sky130_fd_sc_hd__mux4_1
Xhold17 instance_1.data\[0\]\[51\] VGND VGND VPWR VPWR net167 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_46_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold28 instance_1.data\[2\]\[27\] VGND VGND VPWR VPWR net178 sky130_fd_sc_hd__dlygate4sd3_1
Xhold39 instance_1.data\[2\]\[14\] VGND VGND VPWR VPWR net189 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_3_225 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2388_ _1028_ VGND VGND VPWR VPWR _0063_ sky130_fd_sc_hd__clkbuf_1
X_4127_ clknet_leaf_38_clk _0167_ VGND VGND VPWR VPWR instance_2.data\[1\]\[23\] sky130_fd_sc_hd__dfxtp_1
X_4058_ clknet_leaf_41_clk _0098_ VGND VGND VPWR VPWR instance_1.data\[1\]\[26\] sky130_fd_sc_hd__dfxtp_1
X_3009_ _1443_ VGND VGND VPWR VPWR _0269_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_82_978 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_78_376 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_38_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_81_519 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_34_424 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_21_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_16_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_69_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_45_625 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_leaf_54_clk clknet_3_1__leaf_clk VGND VGND VPWR VPWR clknet_leaf_54_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_0_57_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_57_527 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_32_59 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_52_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_479 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold509 instance_2.data\[1\]\[66\] VGND VGND VPWR VPWR net659 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_52_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3360_ net286 _1070_ _1625_ VGND VGND VPWR VPWR _1629_ sky130_fd_sc_hd__mux2_1
XPHY_EDGE_ROW_29_Left_122 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2311_ net330 _0968_ _0949_ VGND VGND VPWR VPWR _0969_ sky130_fd_sc_hd__mux2_1
X_3291_ _1592_ VGND VGND VPWR VPWR _0402_ sky130_fd_sc_hd__clkbuf_1
X_2242_ net183 _0914_ _0915_ VGND VGND VPWR VPWR _0916_ sky130_fd_sc_hd__mux2_1
X_2173_ instance_2.data\[0\]\[15\] instance_2.data\[1\]\[15\] instance_2.data\[2\]\[15\]
+ instance_2.data\[3\]\[15\] _0855_ _0834_ VGND VGND VPWR VPWR _0862_ sky130_fd_sc_hd__mux4_1
XFILLER_0_73_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_leaf_45_clk clknet_3_5__leaf_clk VGND VGND VPWR VPWR clknet_leaf_45_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_0_75_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_38_Left_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_90_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_75_357 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_156 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1957_ instance_1.rdata\[5\] instance_2.rdata\[5\] _0722_ VGND VGND VPWR VPWR _0728_
+ sky130_fd_sc_hd__mux2_1
XFILLER_0_43_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4676_ clknet_leaf_7_clk _0716_ VGND VGND VPWR VPWR instance_2.data\[3\]\[68\] sky130_fd_sc_hd__dfxtp_1
X_3627_ _1768_ VGND VGND VPWR VPWR _0562_ sky130_fd_sc_hd__clkbuf_1
X_3558_ _1732_ VGND VGND VPWR VPWR _0529_ sky130_fd_sc_hd__clkbuf_1
XPHY_EDGE_ROW_47_Left_140 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2509_ _0803_ VGND VGND VPWR VPWR _1122_ sky130_fd_sc_hd__clkbuf_4
X_3489_ _1696_ VGND VGND VPWR VPWR _0496_ sky130_fd_sc_hd__clkbuf_1
Xclkbuf_leaf_36_clk clknet_3_7__leaf_clk VGND VGND VPWR VPWR clknet_leaf_36_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_0_66_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_54_519 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_81_349 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_50_672 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_22_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_89_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_58_750 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_89_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_leaf_27_clk clknet_3_6__leaf_clk VGND VGND VPWR VPWR clknet_leaf_27_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_0_43_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_57_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2860_ _1364_ VGND VGND VPWR VPWR _0199_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_4_115 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_25_232 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2791_ _1328_ VGND VGND VPWR VPWR _0166_ sky130_fd_sc_hd__clkbuf_1
X_4530_ clknet_leaf_3_clk _0570_ VGND VGND VPWR VPWR instance_2.rdata\[66\] sky130_fd_sc_hd__dfxtp_1
Xhold306 instance_1.data\[0\]\[46\] VGND VGND VPWR VPWR net456 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_13_438 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xhold317 instance_1.data\[0\]\[8\] VGND VGND VPWR VPWR net467 sky130_fd_sc_hd__dlygate4sd3_1
X_4461_ clknet_leaf_4_clk _0501_ VGND VGND VPWR VPWR instance_1.data\[2\]\[69\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_40_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_7_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_0_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3412_ net342 _1154_ _1647_ VGND VGND VPWR VPWR _1656_ sky130_fd_sc_hd__mux2_1
Xhold328 instance_2.data\[2\]\[56\] VGND VGND VPWR VPWR net478 sky130_fd_sc_hd__dlygate4sd3_1
Xhold339 instance_2.data\[0\]\[53\] VGND VGND VPWR VPWR net489 sky130_fd_sc_hd__dlygate4sd3_1
X_4392_ clknet_leaf_0_clk _0432_ VGND VGND VPWR VPWR instance_1.data\[2\]\[0\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_90_1056 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3343_ _1619_ VGND VGND VPWR VPWR _0427_ sky130_fd_sc_hd__clkbuf_1
X_3274_ _1583_ VGND VGND VPWR VPWR _0394_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_84_32 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2225_ net2 VGND VGND VPWR VPWR _0902_ sky130_fd_sc_hd__buf_4
X_2156_ instance_2.data\[0\]\[11\] instance_2.data\[1\]\[11\] instance_2.data\[2\]\[11\]
+ instance_2.data\[3\]\[11\] _0821_ _0834_ VGND VGND VPWR VPWR _0849_ sky130_fd_sc_hd__mux4_1
Xclkbuf_leaf_18_clk clknet_3_3__leaf_clk VGND VGND VPWR VPWR clknet_leaf_18_clk sky130_fd_sc_hd__clkbuf_8
XPHY_EDGE_ROW_5_Right_5 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2087_ instance_1.rdata\[67\] instance_2.rdata\[67\] _0788_ VGND VGND VPWR VPWR _0796_
+ sky130_fd_sc_hd__mux2_1
XFILLER_0_44_530 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2989_ _0962_ net661 _1428_ VGND VGND VPWR VPWR _1433_ sky130_fd_sc_hd__mux2_1
X_4659_ clknet_leaf_8_clk _0699_ VGND VGND VPWR VPWR instance_2.data\[3\]\[51\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_39_302 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_55_720 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_27_455 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_13_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_39_346 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_81_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_35_541 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_22_235 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_50_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2010_ instance_1.rdata\[30\] instance_2.rdata\[30\] _0755_ VGND VGND VPWR VPWR _0756_
+ sky130_fd_sc_hd__mux2_1
XFILLER_0_89_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3961_ clknet_leaf_62_clk _0001_ VGND VGND VPWR VPWR instance_2.data\[2\]\[1\] sky130_fd_sc_hd__dfxtp_1
X_2912_ _1392_ VGND VGND VPWR VPWR _0223_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_72_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_61_778 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3892_ _1908_ VGND VGND VPWR VPWR _0687_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_72_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_5_402 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2843_ _1355_ VGND VGND VPWR VPWR _0191_ sky130_fd_sc_hd__clkbuf_1
X_2774_ _1319_ VGND VGND VPWR VPWR _0158_ sky130_fd_sc_hd__clkbuf_1
X_4513_ clknet_leaf_20_clk _0553_ VGND VGND VPWR VPWR instance_2.rdata\[49\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_80_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xhold125 instance_1.data\[1\]\[5\] VGND VGND VPWR VPWR net275 sky130_fd_sc_hd__dlygate4sd3_1
Xhold114 instance_1.data\[1\]\[70\] VGND VGND VPWR VPWR net264 sky130_fd_sc_hd__dlygate4sd3_1
Xhold103 instance_2.data\[3\]\[39\] VGND VGND VPWR VPWR net253 sky130_fd_sc_hd__dlygate4sd3_1
Xhold147 instance_1.data\[0\]\[37\] VGND VGND VPWR VPWR net297 sky130_fd_sc_hd__dlygate4sd3_1
X_4444_ clknet_leaf_16_clk _0484_ VGND VGND VPWR VPWR instance_1.data\[2\]\[52\] sky130_fd_sc_hd__dfxtp_1
Xhold136 instance_1.data\[2\]\[3\] VGND VGND VPWR VPWR net286 sky130_fd_sc_hd__dlygate4sd3_1
Xhold158 instance_1.data\[0\]\[60\] VGND VGND VPWR VPWR net308 sky130_fd_sc_hd__dlygate4sd3_1
Xclkbuf_leaf_7_clk clknet_3_3__leaf_clk VGND VGND VPWR VPWR clknet_leaf_7_clk sky130_fd_sc_hd__clkbuf_8
Xhold169 instance_1.data\[2\]\[36\] VGND VGND VPWR VPWR net319 sky130_fd_sc_hd__dlygate4sd3_1
X_4375_ clknet_leaf_13_clk _0415_ VGND VGND VPWR VPWR instance_1.rdata\[55\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_21_290 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3326_ _1610_ VGND VGND VPWR VPWR _0419_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_0_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3257_ _1574_ VGND VGND VPWR VPWR _0386_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_69_856 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3188_ net179 _1283_ _1531_ VGND VGND VPWR VPWR _1538_ sky130_fd_sc_hd__mux2_1
X_2208_ net1 VGND VGND VPWR VPWR _0889_ sky130_fd_sc_hd__buf_4
X_2139_ _0835_ net73 _0806_ VGND VGND VPWR VPWR _0836_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_24_425 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_76_496 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_63_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_8_240 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_541 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_32_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_71_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold670 instance_1.data\[1\]\[4\] VGND VGND VPWR VPWR net820 sky130_fd_sc_hd__dlygate4sd3_1
Xhold681 instance_2.rdata\[40\] VGND VGND VPWR VPWR net831 sky130_fd_sc_hd__dlygate4sd3_1
Xhold692 instance_2.data\[0\]\[45\] VGND VGND VPWR VPWR net842 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_86_205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_27_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_39_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_82_444 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_50_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_10_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2490_ net366 _1107_ _1094_ VGND VGND VPWR VPWR _1108_ sky130_fd_sc_hd__mux2_1
XFILLER_0_50_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_49_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_49_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_4_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4160_ clknet_leaf_12_clk _0200_ VGND VGND VPWR VPWR instance_2.data\[1\]\[56\] sky130_fd_sc_hd__dfxtp_1
X_3111_ _1497_ VGND VGND VPWR VPWR _0317_ sky130_fd_sc_hd__clkbuf_1
X_4091_ clknet_leaf_14_clk _0131_ VGND VGND VPWR VPWR instance_1.data\[1\]\[59\] sky130_fd_sc_hd__dfxtp_1
X_3042_ _1460_ VGND VGND VPWR VPWR _0285_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_66_826 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_81_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3944_ net643 _1030_ _1931_ VGND VGND VPWR VPWR _1936_ sky130_fd_sc_hd__mux2_1
X_3875_ net606 _0918_ _1898_ VGND VGND VPWR VPWR _1900_ sky130_fd_sc_hd__mux2_1
XFILLER_0_73_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_33_308 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2826_ _1346_ VGND VGND VPWR VPWR _0183_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_14_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_371 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_60_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2757_ _1310_ VGND VGND VPWR VPWR _0150_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_30_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_60_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2688_ net488 _1260_ _1230_ VGND VGND VPWR VPWR _1261_ sky130_fd_sc_hd__mux2_1
X_4427_ clknet_leaf_30_clk _0467_ VGND VGND VPWR VPWR instance_1.data\[2\]\[35\] sky130_fd_sc_hd__dfxtp_1
X_4358_ clknet_leaf_28_clk _0398_ VGND VGND VPWR VPWR instance_1.rdata\[38\] sky130_fd_sc_hd__dfxtp_1
X_4289_ clknet_leaf_26_clk _0329_ VGND VGND VPWR VPWR instance_1.data\[3\]\[41\] sky130_fd_sc_hd__dfxtp_1
X_3309_ net258 _1232_ _1600_ VGND VGND VPWR VPWR _1602_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_37_550 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_76_271 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_76_282 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_64_444 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_36_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_17_371 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_10_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_44_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_51_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_20_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_19_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_9_286 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_87_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1990_ _0745_ VGND VGND VPWR VPWR net89 sky130_fd_sc_hd__buf_1
XTAP_TAPCELL_ROW_71_873 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_27_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_55_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3660_ _1786_ VGND VGND VPWR VPWR _0577_ sky130_fd_sc_hd__clkbuf_1
X_2611_ _1201_ VGND VGND VPWR VPWR _0113_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_70_458 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3591_ _0951_ net564 _1748_ VGND VGND VPWR VPWR _1750_ sky130_fd_sc_hd__mux2_1
XFILLER_0_2_224 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2542_ net22 _1147_ _1131_ VGND VGND VPWR VPWR _1148_ sky130_fd_sc_hd__mux2_1
XPHY_EDGE_ROW_10_Left_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4212_ clknet_leaf_32_clk _0252_ VGND VGND VPWR VPWR instance_2.data\[0\]\[36\] sky130_fd_sc_hd__dfxtp_1
X_2473_ net715 _1093_ _1094_ VGND VGND VPWR VPWR _1095_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_79_951 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4143_ clknet_leaf_23_clk _0183_ VGND VGND VPWR VPWR instance_2.data\[1\]\[39\] sky130_fd_sc_hd__dfxtp_1
X_4074_ clknet_leaf_27_clk _0114_ VGND VGND VPWR VPWR instance_1.data\[1\]\[42\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_87_1028 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3025_ _1020_ net611 _1450_ VGND VGND VPWR VPWR _1452_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_34_520 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_46_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3927_ net327 _1002_ _1920_ VGND VGND VPWR VPWR _1927_ sky130_fd_sc_hd__mux2_1
X_3858_ net195 _0891_ _1887_ VGND VGND VPWR VPWR _1891_ sky130_fd_sc_hd__mux2_1
XFILLER_0_26_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3789_ net766 _1274_ _1850_ VGND VGND VPWR VPWR _1854_ sky130_fd_sc_hd__mux2_1
X_2809_ net544 _0918_ _1336_ VGND VGND VPWR VPWR _1338_ sky130_fd_sc_hd__mux2_1
XFILLER_0_14_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_6_256 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_21_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_37_499 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_40_578 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_17_190 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_20_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_20_344 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_76_921 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_1_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_48_656 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_62_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1973_ _0736_ VGND VGND VPWR VPWR net80 sky130_fd_sc_hd__clkbuf_1
X_3712_ _1813_ VGND VGND VPWR VPWR _0602_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_70_211 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3643_ _1035_ net840 _1770_ VGND VGND VPWR VPWR _1777_ sky130_fd_sc_hd__mux2_1
XFILLER_0_3_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3574_ _0924_ net848 _1737_ VGND VGND VPWR VPWR _1741_ sky130_fd_sc_hd__mux2_1
XFILLER_0_11_311 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2525_ net18 _1134_ _1131_ VGND VGND VPWR VPWR _1135_ sky130_fd_sc_hd__mux2_1
X_2456_ _1081_ VGND VGND VPWR VPWR _0078_ sky130_fd_sc_hd__clkbuf_1
Xhold29 instance_1.data\[3\]\[66\] VGND VGND VPWR VPWR net179 sky130_fd_sc_hd__dlygate4sd3_1
Xhold18 instance_1.data\[1\]\[68\] VGND VGND VPWR VPWR net168 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_3_226 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4126_ clknet_leaf_52_clk _0166_ VGND VGND VPWR VPWR instance_2.data\[1\]\[22\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_39_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2387_ net534 _1027_ _1017_ VGND VGND VPWR VPWR _1028_ sky130_fd_sc_hd__mux2_1
X_4057_ clknet_leaf_41_clk _0097_ VGND VGND VPWR VPWR instance_1.data\[1\]\[25\] sky130_fd_sc_hd__dfxtp_1
X_3008_ _0993_ net489 _1439_ VGND VGND VPWR VPWR _1443_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_82_979 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_19_380 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_19_411 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_74_550 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_61_211 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_34_436 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_45_626 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_69_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_57_517 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_84_336 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_32_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_80_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_52_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_40_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3290_ net209 _1202_ _1589_ VGND VGND VPWR VPWR _1592_ sky130_fd_sc_hd__mux2_1
X_2310_ _0967_ net44 _0944_ VGND VGND VPWR VPWR _0968_ sky130_fd_sc_hd__mux2_1
X_2241_ _0812_ VGND VGND VPWR VPWR _0915_ sky130_fd_sc_hd__buf_4
XFILLER_0_57_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2172_ _0861_ VGND VGND VPWR VPWR _0014_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_16_350 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_75_369 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_90_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1956_ _0727_ VGND VGND VPWR VPWR net121 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_28_285 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_16_458 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_43_244 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4675_ clknet_leaf_5_clk _0715_ VGND VGND VPWR VPWR instance_2.data\[3\]\[67\] sky130_fd_sc_hd__dfxtp_1
X_3626_ _1008_ net870 _1759_ VGND VGND VPWR VPWR _1768_ sky130_fd_sc_hd__mux2_1
X_3557_ _0896_ net747 _1726_ VGND VGND VPWR VPWR _1732_ sky130_fd_sc_hd__mux2_1
X_2508_ _1121_ VGND VGND VPWR VPWR _0090_ sky130_fd_sc_hd__clkbuf_1
X_3488_ net634 _1277_ _1691_ VGND VGND VPWR VPWR _1696_ sky130_fd_sc_hd__mux2_1
X_2439_ _1068_ VGND VGND VPWR VPWR _0074_ sky130_fd_sc_hd__clkbuf_1
X_4109_ clknet_leaf_55_clk _0149_ VGND VGND VPWR VPWR instance_2.data\[1\]\[5\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_78_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_81_306 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_50_673 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_62_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_89_417 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_58_751 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_43_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_43_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_13_320 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2790_ net538 _0887_ _1325_ VGND VGND VPWR VPWR _1328_ sky130_fd_sc_hd__mux2_1
XFILLER_0_65_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_80_350 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_255 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_7_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold307 instance_1.rdata\[21\] VGND VGND VPWR VPWR net457 sky130_fd_sc_hd__dlygate4sd3_1
X_4460_ clknet_leaf_4_clk _0500_ VGND VGND VPWR VPWR instance_1.data\[2\]\[68\] sky130_fd_sc_hd__dfxtp_1
Xhold318 instance_1.data\[0\]\[36\] VGND VGND VPWR VPWR net468 sky130_fd_sc_hd__dlygate4sd3_1
X_4391_ clknet_leaf_54_clk _0431_ VGND VGND VPWR VPWR instance_1.rdata\[71\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_40_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3411_ _1655_ VGND VGND VPWR VPWR _0459_ sky130_fd_sc_hd__clkbuf_1
Xhold329 instance_2.data\[2\]\[42\] VGND VGND VPWR VPWR net479 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_0_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3342_ net524 _1285_ _1611_ VGND VGND VPWR VPWR _1619_ sky130_fd_sc_hd__mux2_1
XFILLER_0_68_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_90_1057 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3273_ net614 _1174_ _1578_ VGND VGND VPWR VPWR _1583_ sky130_fd_sc_hd__mux2_1
X_2224_ _0901_ VGND VGND VPWR VPWR _0026_ sky130_fd_sc_hd__clkbuf_1
X_2155_ _0848_ VGND VGND VPWR VPWR _0010_ sky130_fd_sc_hd__clkbuf_1
X_2086_ _0795_ VGND VGND VPWR VPWR net139 sky130_fd_sc_hd__buf_1
XFILLER_0_48_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_48_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_16_211 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2988_ _1432_ VGND VGND VPWR VPWR _0259_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_31_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_31_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4658_ clknet_leaf_20_clk _0698_ VGND VGND VPWR VPWR instance_2.data\[3\]\[50\] sky130_fd_sc_hd__dfxtp_1
X_3609_ _1300_ VGND VGND VPWR VPWR _1759_ sky130_fd_sc_hd__clkbuf_4
X_4589_ clknet_leaf_16_clk _0629_ VGND VGND VPWR VPWR instance_1.data\[0\]\[53\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_55_721 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_27_456 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_39_314 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_11_Right_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_54_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_66_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_47_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_1_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_1_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_50_545 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_20_Right_20 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_66_Left_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_89_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3960_ clknet_leaf_62_clk _0000_ VGND VGND VPWR VPWR instance_2.data\[2\]\[0\] sky130_fd_sc_hd__dfxtp_1
X_2911_ _0836_ net810 _1384_ VGND VGND VPWR VPWR _1392_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_61_779 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3891_ net253 _0945_ _1898_ VGND VGND VPWR VPWR _1908_ sky130_fd_sc_hd__mux2_1
XPHY_EDGE_ROW_75_Left_168 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_26_520 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2842_ net591 _0972_ _1347_ VGND VGND VPWR VPWR _1355_ sky130_fd_sc_hd__mux2_1
X_2773_ net395 _0860_ _1314_ VGND VGND VPWR VPWR _1319_ sky130_fd_sc_hd__mux2_1
X_4512_ clknet_leaf_19_clk _0552_ VGND VGND VPWR VPWR instance_2.rdata\[48\] sky130_fd_sc_hd__dfxtp_1
Xhold126 instance_2.data\[2\]\[34\] VGND VGND VPWR VPWR net276 sky130_fd_sc_hd__dlygate4sd3_1
Xhold115 instance_1.data\[1\]\[20\] VGND VGND VPWR VPWR net265 sky130_fd_sc_hd__dlygate4sd3_1
Xhold104 instance_1.data\[3\]\[22\] VGND VGND VPWR VPWR net254 sky130_fd_sc_hd__dlygate4sd3_1
X_4443_ clknet_leaf_17_clk _0483_ VGND VGND VPWR VPWR instance_1.data\[2\]\[51\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_79_99 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xhold137 instance_2.data\[2\]\[33\] VGND VGND VPWR VPWR net287 sky130_fd_sc_hd__dlygate4sd3_1
Xhold148 instance_1.data\[3\]\[27\] VGND VGND VPWR VPWR net298 sky130_fd_sc_hd__dlygate4sd3_1
Xhold159 instance_2.data\[0\]\[55\] VGND VGND VPWR VPWR net309 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_0_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_0_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4374_ clknet_leaf_13_clk _0414_ VGND VGND VPWR VPWR instance_1.rdata\[54\] sky130_fd_sc_hd__dfxtp_1
X_3325_ net361 _1259_ _1600_ VGND VGND VPWR VPWR _1610_ sky130_fd_sc_hd__mux2_1
XPHY_EDGE_ROW_84_Left_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3256_ net294 _1147_ _1567_ VGND VGND VPWR VPWR _1574_ sky130_fd_sc_hd__mux2_1
X_2207_ _0888_ VGND VGND VPWR VPWR _0022_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_69_857 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_21_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3187_ _1537_ VGND VGND VPWR VPWR _0353_ sky130_fd_sc_hd__clkbuf_1
X_2138_ instance_2.data\[0\]\[7\] instance_2.data\[1\]\[7\] instance_2.data\[2\]\[7\]
+ instance_2.data\[3\]\[7\] _0821_ _0834_ VGND VGND VPWR VPWR _0835_ sky130_fd_sc_hd__mux4_1
X_2069_ _0786_ VGND VGND VPWR VPWR net130 sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_24_426 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_76_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_8_230 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_29_380 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_63_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_63_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_32_545 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold660 instance_2.data\[0\]\[7\] VGND VGND VPWR VPWR net810 sky130_fd_sc_hd__dlygate4sd3_1
Xhold671 instance_2.data\[0\]\[60\] VGND VGND VPWR VPWR net821 sky130_fd_sc_hd__dlygate4sd3_1
Xhold682 instance_2.data\[2\]\[58\] VGND VGND VPWR VPWR net832 sky130_fd_sc_hd__dlygate4sd3_1
Xhold693 instance_2.data\[0\]\[41\] VGND VGND VPWR VPWR net843 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_86_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_39_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_67_486 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_27_328 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_40_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_42_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_4_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3110_ net666 _1158_ _1487_ VGND VGND VPWR VPWR _1497_ sky130_fd_sc_hd__mux2_1
X_4090_ clknet_leaf_14_clk _0130_ VGND VGND VPWR VPWR instance_1.data\[1\]\[58\] sky130_fd_sc_hd__dfxtp_1
X_3041_ _1046_ net295 _1450_ VGND VGND VPWR VPWR _1460_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_66_827 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3943_ _1935_ VGND VGND VPWR VPWR _0711_ sky130_fd_sc_hd__clkbuf_1
X_3874_ _1899_ VGND VGND VPWR VPWR _0678_ sky130_fd_sc_hd__clkbuf_1
Xclkbuf_3_2__f_clk clknet_0_clk VGND VGND VPWR VPWR clknet_3_2__leaf_clk sky130_fd_sc_hd__clkbuf_16
X_2825_ net440 _0945_ _1336_ VGND VGND VPWR VPWR _1346_ sky130_fd_sc_hd__mux2_1
XFILLER_0_14_545 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2756_ net384 _0832_ _1303_ VGND VGND VPWR VPWR _1310_ sky130_fd_sc_hd__mux2_1
X_2687_ net58 _1259_ _1233_ VGND VGND VPWR VPWR _1260_ sky130_fd_sc_hd__mux2_1
X_4426_ clknet_leaf_31_clk _0466_ VGND VGND VPWR VPWR instance_1.data\[2\]\[34\] sky130_fd_sc_hd__dfxtp_1
X_4357_ clknet_leaf_30_clk _0397_ VGND VGND VPWR VPWR instance_1.rdata\[37\] sky130_fd_sc_hd__dfxtp_1
X_4288_ clknet_leaf_26_clk _0328_ VGND VGND VPWR VPWR instance_1.data\[3\]\[40\] sky130_fd_sc_hd__dfxtp_1
X_3308_ _1601_ VGND VGND VPWR VPWR _0410_ sky130_fd_sc_hd__clkbuf_1
X_3239_ net508 _1119_ _1556_ VGND VGND VPWR VPWR _1565_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_37_551 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_76_294 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_36_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_91_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_36_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_32_342 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xhold490 instance_2.data\[3\]\[35\] VGND VGND VPWR VPWR net640 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_9_287 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_19_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_71_874 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_82_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_27_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_27_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_55_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_55_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2610_ net328 _1200_ _1196_ VGND VGND VPWR VPWR _1201_ sky130_fd_sc_hd__mux2_1
X_3590_ _1749_ VGND VGND VPWR VPWR _0544_ sky130_fd_sc_hd__clkbuf_1
X_2541_ instance_1.data\[0\]\[26\] instance_1.data\[1\]\[26\] instance_1.data\[2\]\[26\]
+ instance_1.data\[3\]\[26\] _1143_ _1122_ VGND VGND VPWR VPWR _1147_ sky130_fd_sc_hd__mux4_1
X_2472_ _1059_ VGND VGND VPWR VPWR _1094_ sky130_fd_sc_hd__buf_4
X_4211_ clknet_leaf_36_clk _0251_ VGND VGND VPWR VPWR instance_2.data\[0\]\[35\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_79_952 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4142_ clknet_leaf_24_clk _0182_ VGND VGND VPWR VPWR instance_2.data\[1\]\[38\] sky130_fd_sc_hd__dfxtp_1
X_4073_ clknet_leaf_27_clk _0113_ VGND VGND VPWR VPWR instance_1.data\[1\]\[41\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_87_1029 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3024_ _1451_ VGND VGND VPWR VPWR _0276_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_78_526 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_34_521 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3926_ _1926_ VGND VGND VPWR VPWR _0703_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_6_520 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_46_445 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_33_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3857_ _1890_ VGND VGND VPWR VPWR _0670_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_14_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3788_ _1853_ VGND VGND VPWR VPWR _0638_ sky130_fd_sc_hd__clkbuf_1
X_2808_ _1337_ VGND VGND VPWR VPWR _0174_ sky130_fd_sc_hd__clkbuf_1
X_2739_ _1299_ VGND VGND VPWR VPWR _0143_ sky130_fd_sc_hd__clkbuf_1
X_4409_ clknet_leaf_43_clk _0449_ VGND VGND VPWR VPWR instance_1.data\[2\]\[17\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_6_257 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_5_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_5_92 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_92_551 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_64_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_24_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_40_579 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_76_922 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_48_657 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_87_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_1_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_75_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_28_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_83_540 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1972_ instance_1.rdata\[12\] instance_2.rdata\[12\] _0733_ VGND VGND VPWR VPWR _0736_
+ sky130_fd_sc_hd__mux2_1
X_3711_ net449 _1148_ _1806_ VGND VGND VPWR VPWR _1813_ sky130_fd_sc_hd__mux2_1
XFILLER_0_11_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3642_ _1776_ VGND VGND VPWR VPWR _0569_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_3_545 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_49_Right_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3573_ _1740_ VGND VGND VPWR VPWR _0536_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_87_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2524_ instance_1.data\[0\]\[22\] instance_1.data\[1\]\[22\] instance_1.data\[2\]\[22\]
+ instance_1.data\[3\]\[22\] _1109_ _1122_ VGND VGND VPWR VPWR _1134_ sky130_fd_sc_hd__mux4_1
X_2455_ net594 _1080_ _1060_ VGND VGND VPWR VPWR _1081_ sky130_fd_sc_hd__mux2_1
Xhold19 instance_2.data\[1\]\[36\] VGND VGND VPWR VPWR net169 sky130_fd_sc_hd__dlygate4sd3_1
X_2386_ _1026_ net63 _1012_ VGND VGND VPWR VPWR _1027_ sky130_fd_sc_hd__mux2_1
X_4125_ clknet_leaf_52_clk _0165_ VGND VGND VPWR VPWR instance_2.data\[1\]\[21\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_3_227 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4056_ clknet_leaf_41_clk _0096_ VGND VGND VPWR VPWR instance_1.data\[1\]\[24\] sky130_fd_sc_hd__dfxtp_1
XPHY_EDGE_ROW_58_Right_58 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3007_ _1442_ VGND VGND VPWR VPWR _0268_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_19_381 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_66_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3909_ _1917_ VGND VGND VPWR VPWR _0695_ sky130_fd_sc_hd__clkbuf_1
XPHY_EDGE_ROW_67_Right_67 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_76_Right_76 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_88_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_16_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_45_627 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_85_Right_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_52_212 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_20_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_20_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_20_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_57_36 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2240_ _0913_ net27 _0910_ VGND VGND VPWR VPWR _0914_ sky130_fd_sc_hd__mux2_1
X_2171_ net435 _0860_ _0847_ VGND VGND VPWR VPWR _0861_ sky130_fd_sc_hd__mux2_1
XFILLER_0_73_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_16_351 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1955_ instance_1.rdata\[4\] instance_2.rdata\[4\] _0722_ VGND VGND VPWR VPWR _0727_
+ sky130_fd_sc_hd__mux2_1
XFILLER_0_28_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_7_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_22_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_28_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4674_ clknet_leaf_3_clk _0714_ VGND VGND VPWR VPWR instance_2.data\[3\]\[66\] sky130_fd_sc_hd__dfxtp_1
X_3625_ _1767_ VGND VGND VPWR VPWR _0561_ sky130_fd_sc_hd__clkbuf_1
X_3556_ _1731_ VGND VGND VPWR VPWR _0528_ sky130_fd_sc_hd__clkbuf_1
X_2507_ net194 _1120_ _1094_ VGND VGND VPWR VPWR _1121_ sky130_fd_sc_hd__mux2_1
X_3487_ _1695_ VGND VGND VPWR VPWR _0495_ sky130_fd_sc_hd__clkbuf_1
X_2438_ net187 _1067_ _1060_ VGND VGND VPWR VPWR _1068_ sky130_fd_sc_hd__mux2_1
X_2369_ net459 _1013_ _0983_ VGND VGND VPWR VPWR _1014_ sky130_fd_sc_hd__mux2_1
X_4108_ clknet_leaf_59_clk _0148_ VGND VGND VPWR VPWR instance_2.data\[1\]\[4\] sky130_fd_sc_hd__dfxtp_1
X_4039_ clknet_leaf_57_clk _0079_ VGND VGND VPWR VPWR instance_1.data\[1\]\[7\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_81_318 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_19_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_34_234 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_50_674 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_22_418 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_27_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_89_429 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_58_752 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_69_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_72_318 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_72_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_13_321 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_38_551 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_80_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_13_407 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_7_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xhold308 instance_2.data\[0\]\[5\] VGND VGND VPWR VPWR net458 sky130_fd_sc_hd__dlygate4sd3_1
Xhold319 instance_2.data\[3\]\[36\] VGND VGND VPWR VPWR net469 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_0_312 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4390_ clknet_leaf_53_clk _0430_ VGND VGND VPWR VPWR instance_1.rdata\[70\] sky130_fd_sc_hd__dfxtp_1
X_3410_ net178 _1151_ _1647_ VGND VGND VPWR VPWR _1655_ sky130_fd_sc_hd__mux2_1
XFILLER_0_68_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_0_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3341_ _1618_ VGND VGND VPWR VPWR _0426_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_90_1058 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3272_ _1582_ VGND VGND VPWR VPWR _0393_ sky130_fd_sc_hd__clkbuf_1
X_2223_ net290 _0900_ _0881_ VGND VGND VPWR VPWR _0901_ sky130_fd_sc_hd__mux2_1
X_2154_ net559 _0846_ _0847_ VGND VGND VPWR VPWR _0848_ sky130_fd_sc_hd__mux2_1
X_2085_ instance_1.rdata\[66\] instance_2.rdata\[66\] _0788_ VGND VGND VPWR VPWR _0795_
+ sky130_fd_sc_hd__mux2_1
XFILLER_0_88_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_75_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_44_510 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2987_ _0959_ net827 _1428_ VGND VGND VPWR VPWR _1432_ sky130_fd_sc_hd__mux2_1
X_4657_ clknet_leaf_7_clk _0697_ VGND VGND VPWR VPWR instance_2.data\[3\]\[49\] sky130_fd_sc_hd__dfxtp_1
X_3608_ _1758_ VGND VGND VPWR VPWR _0553_ sky130_fd_sc_hd__clkbuf_1
X_4588_ clknet_leaf_16_clk _0628_ VGND VGND VPWR VPWR instance_1.data\[0\]\[52\] sky130_fd_sc_hd__dfxtp_1
X_3539_ _1722_ VGND VGND VPWR VPWR _0520_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_55_722 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_27_457 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_54_318 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_54_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2910_ _1391_ VGND VGND VPWR VPWR _0222_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_57_134 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3890_ _1907_ VGND VGND VPWR VPWR _0686_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_85_498 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_57_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2841_ _1354_ VGND VGND VPWR VPWR _0190_ sky130_fd_sc_hd__clkbuf_1
X_2772_ _1318_ VGND VGND VPWR VPWR _0157_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_41_502 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4511_ clknet_leaf_21_clk _0551_ VGND VGND VPWR VPWR instance_2.rdata\[47\] sky130_fd_sc_hd__dfxtp_1
X_4442_ clknet_leaf_17_clk _0482_ VGND VGND VPWR VPWR instance_1.data\[2\]\[50\] sky130_fd_sc_hd__dfxtp_1
Xhold105 instance_1.rdata\[35\] VGND VGND VPWR VPWR net255 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_13_259 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_13_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold116 instance_2.data\[1\]\[50\] VGND VGND VPWR VPWR net266 sky130_fd_sc_hd__dlygate4sd3_1
Xhold149 instance_2.data\[1\]\[5\] VGND VGND VPWR VPWR net299 sky130_fd_sc_hd__dlygate4sd3_1
Xhold127 instance_1.data\[0\]\[29\] VGND VGND VPWR VPWR net277 sky130_fd_sc_hd__dlygate4sd3_1
Xhold138 instance_2.data\[2\]\[32\] VGND VGND VPWR VPWR net288 sky130_fd_sc_hd__dlygate4sd3_1
X_4373_ clknet_leaf_16_clk _0413_ VGND VGND VPWR VPWR instance_1.rdata\[53\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_0_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3324_ _1609_ VGND VGND VPWR VPWR _0418_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_0_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_0_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3255_ _1573_ VGND VGND VPWR VPWR _0385_ sky130_fd_sc_hd__clkbuf_1
X_2206_ net772 _0887_ _0881_ VGND VGND VPWR VPWR _0888_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_69_858 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3186_ net226 _1280_ _1531_ VGND VGND VPWR VPWR _1537_ sky130_fd_sc_hd__mux2_1
XFILLER_0_14_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2137_ _0803_ VGND VGND VPWR VPWR _0834_ sky130_fd_sc_hd__clkbuf_4
X_2068_ instance_1.rdata\[58\] instance_2.rdata\[58\] _0777_ VGND VGND VPWR VPWR _0786_
+ sky130_fd_sc_hd__mux2_1
XFILLER_0_44_70 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_88_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_24_427 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_36_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_8_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_44_395 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xhold672 instance_2.data\[0\]\[10\] VGND VGND VPWR VPWR net822 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_12_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold650 instance_1.data\[2\]\[4\] VGND VGND VPWR VPWR net800 sky130_fd_sc_hd__dlygate4sd3_1
Xhold661 instance_2.data\[0\]\[48\] VGND VGND VPWR VPWR net811 sky130_fd_sc_hd__dlygate4sd3_1
Xhold683 instance_2.data\[0\]\[67\] VGND VGND VPWR VPWR net833 sky130_fd_sc_hd__dlygate4sd3_1
Xhold694 instance_2.rdata\[48\] VGND VGND VPWR VPWR net844 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_24_18 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_24_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_79_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_39_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_67_498 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_23_502 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_35_384 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_50_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3040_ _1459_ VGND VGND VPWR VPWR _0284_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_66_828 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_81_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_18_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3942_ net550 _1027_ _1931_ VGND VGND VPWR VPWR _1935_ sky130_fd_sc_hd__mux2_1
XFILLER_0_18_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3873_ net689 _0914_ _1898_ VGND VGND VPWR VPWR _1899_ sky130_fd_sc_hd__mux2_1
X_2824_ _1345_ VGND VGND VPWR VPWR _0182_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_5_289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2755_ _1309_ VGND VGND VPWR VPWR _0149_ sky130_fd_sc_hd__clkbuf_1
X_2686_ instance_1.data\[0\]\[59\] instance_1.data\[1\]\[59\] instance_1.data\[2\]\[59\]
+ instance_1.data\[3\]\[59\] _1245_ _1258_ VGND VGND VPWR VPWR _1259_ sky130_fd_sc_hd__mux4_1
X_4425_ clknet_leaf_31_clk _0465_ VGND VGND VPWR VPWR instance_1.data\[2\]\[33\] sky130_fd_sc_hd__dfxtp_1
X_4356_ clknet_leaf_30_clk _0396_ VGND VGND VPWR VPWR instance_1.rdata\[36\] sky130_fd_sc_hd__dfxtp_1
X_3307_ net511 _1228_ _1600_ VGND VGND VPWR VPWR _1601_ sky130_fd_sc_hd__mux2_1
X_4287_ clknet_leaf_28_clk _0327_ VGND VGND VPWR VPWR instance_1.data\[3\]\[39\] sky130_fd_sc_hd__dfxtp_1
X_3238_ _1564_ VGND VGND VPWR VPWR _0377_ sky130_fd_sc_hd__clkbuf_1
X_3169_ net497 _1253_ _1520_ VGND VGND VPWR VPWR _1528_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_37_552 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_76_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_49_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_17_340 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_91_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_351 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_3_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold480 instance_2.data\[1\]\[32\] VGND VGND VPWR VPWR net630 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_9_288 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xhold491 instance_2.rdata\[67\] VGND VGND VPWR VPWR net641 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_35_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_87_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_87_549 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_71_875 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_55_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_11_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_354 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2540_ _1146_ VGND VGND VPWR VPWR _0097_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_50_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2471_ net5 _1092_ _1063_ VGND VGND VPWR VPWR _1093_ sky130_fd_sc_hd__mux2_1
XFILLER_0_11_549 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4210_ clknet_leaf_31_clk _0250_ VGND VGND VPWR VPWR instance_2.data\[0\]\[34\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_50_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_79_953 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4141_ clknet_leaf_29_clk _0181_ VGND VGND VPWR VPWR instance_2.data\[1\]\[37\] sky130_fd_sc_hd__dfxtp_1
X_4072_ clknet_leaf_25_clk _0112_ VGND VGND VPWR VPWR instance_1.data\[1\]\[40\] sky130_fd_sc_hd__dfxtp_1
X_3023_ _1016_ net821 _1450_ VGND VGND VPWR VPWR _1451_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_34_522 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3925_ net612 _0999_ _1920_ VGND VGND VPWR VPWR _1926_ sky130_fd_sc_hd__mux2_1
XFILLER_0_46_457 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3856_ net805 _0887_ _1887_ VGND VGND VPWR VPWR _1890_ sky130_fd_sc_hd__mux2_1
XFILLER_0_61_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_81_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3787_ net775 _1271_ _1850_ VGND VGND VPWR VPWR _1853_ sky130_fd_sc_hd__mux2_1
X_2807_ net233 _0914_ _1336_ VGND VGND VPWR VPWR _1337_ sky130_fd_sc_hd__mux2_1
XFILLER_0_61_438 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_61_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2738_ net389 _1298_ _1059_ VGND VGND VPWR VPWR _1299_ sky130_fd_sc_hd__mux2_1
X_2669_ instance_1.data\[0\]\[55\] instance_1.data\[1\]\[55\] instance_1.data\[2\]\[55\]
+ instance_1.data\[3\]\[55\] _1245_ _1224_ VGND VGND VPWR VPWR _1246_ sky130_fd_sc_hd__mux4_1
X_4408_ clknet_leaf_47_clk _0448_ VGND VGND VPWR VPWR instance_1.data\[2\]\[16\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_6_258 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4339_ clknet_leaf_43_clk _0379_ VGND VGND VPWR VPWR instance_1.rdata\[19\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_37_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_64_298 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_32_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_60_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_76_923 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_leaf_57_clk clknet_3_1__leaf_clk VGND VGND VPWR VPWR clknet_leaf_57_clk sky130_fd_sc_hd__clkbuf_8
XTAP_TAPCELL_ROW_48_658 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_87_324 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1971_ _0735_ VGND VGND VPWR VPWR net79 sky130_fd_sc_hd__clkbuf_1
X_3710_ _1812_ VGND VGND VPWR VPWR _0601_ sky130_fd_sc_hd__clkbuf_1
X_3641_ _1032_ net781 _1770_ VGND VGND VPWR VPWR _1776_ sky130_fd_sc_hd__mux2_1
X_3572_ _0920_ net823 _1737_ VGND VGND VPWR VPWR _1740_ sky130_fd_sc_hd__mux2_1
XFILLER_0_70_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2523_ _1133_ VGND VGND VPWR VPWR _0093_ sky130_fd_sc_hd__clkbuf_1
X_2454_ net70 _1079_ _1063_ VGND VGND VPWR VPWR _1080_ sky130_fd_sc_hd__mux2_1
X_2385_ instance_2.data\[0\]\[63\] instance_2.data\[1\]\[63\] instance_2.data\[2\]\[63\]
+ instance_2.data\[3\]\[63\] _1025_ _1004_ VGND VGND VPWR VPWR _1026_ sky130_fd_sc_hd__mux4_1
X_4124_ clknet_leaf_52_clk _0164_ VGND VGND VPWR VPWR instance_2.data\[1\]\[20\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_3_228 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xinput1 address[0] VGND VGND VPWR VPWR net1 sky130_fd_sc_hd__clkbuf_4
Xclkbuf_leaf_48_clk clknet_3_4__leaf_clk VGND VGND VPWR VPWR clknet_leaf_48_clk sky130_fd_sc_hd__clkbuf_8
X_4055_ clknet_leaf_42_clk _0095_ VGND VGND VPWR VPWR instance_1.data\[1\]\[23\] sky130_fd_sc_hd__dfxtp_1
X_3006_ _0989_ net616 _1439_ VGND VGND VPWR VPWR _1442_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_19_382 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3908_ net743 _0972_ _1909_ VGND VGND VPWR VPWR _1917_ sky130_fd_sc_hd__mux2_1
X_3839_ net495 _0860_ _1876_ VGND VGND VPWR VPWR _1881_ sky130_fd_sc_hd__mux2_1
Xclkbuf_leaf_39_clk clknet_3_4__leaf_clk VGND VGND VPWR VPWR clknet_leaf_39_clk sky130_fd_sc_hd__clkbuf_8
XTAP_TAPCELL_ROW_45_628 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_81_970 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_92_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_80_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_25_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_2_Left_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_33_482 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_0_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_57_48 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2170_ _0859_ net9 _0842_ VGND VGND VPWR VPWR _0860_ sky130_fd_sc_hd__mux2_1
XFILLER_0_73_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_87_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_16_352 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1954_ _0726_ VGND VGND VPWR VPWR net110 sky130_fd_sc_hd__clkbuf_1
X_4673_ clknet_leaf_9_clk _0713_ VGND VGND VPWR VPWR instance_2.data\[3\]\[65\] sky130_fd_sc_hd__dfxtp_1
X_3624_ _1005_ net806 _1759_ VGND VGND VPWR VPWR _1767_ sky130_fd_sc_hd__mux2_1
XFILLER_0_43_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_11_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3555_ _0893_ net807 _1726_ VGND VGND VPWR VPWR _1731_ sky130_fd_sc_hd__mux2_1
X_2506_ net13 _1119_ _1097_ VGND VGND VPWR VPWR _1120_ sky130_fd_sc_hd__mux2_1
X_3486_ net746 _1274_ _1691_ VGND VGND VPWR VPWR _1695_ sky130_fd_sc_hd__mux2_1
X_2437_ net26 _1066_ _1063_ VGND VGND VPWR VPWR _1067_ sky130_fd_sc_hd__mux2_1
XFILLER_0_44_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2368_ _1011_ net58 _1012_ VGND VGND VPWR VPWR _1013_ sky130_fd_sc_hd__mux2_1
X_4107_ clknet_leaf_60_clk _0147_ VGND VGND VPWR VPWR instance_2.data\[1\]\[3\] sky130_fd_sc_hd__dfxtp_1
X_2299_ net477 _0959_ _0949_ VGND VGND VPWR VPWR _0960_ sky130_fd_sc_hd__mux2_1
X_4038_ clknet_leaf_58_clk _0078_ VGND VGND VPWR VPWR instance_1.data\[1\]\[6\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_19_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_47_541 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_34_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_50_675 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_34_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_15_460 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_58_753 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_84_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_13_322 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_65_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_7_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold309 instance_2.data\[2\]\[59\] VGND VGND VPWR VPWR net459 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_68_14 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3340_ net405 _1282_ _1611_ VGND VGND VPWR VPWR _1618_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_90_1059 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3271_ net537 _1171_ _1578_ VGND VGND VPWR VPWR _1582_ sky130_fd_sc_hd__mux2_1
X_2222_ _0899_ net22 _0876_ VGND VGND VPWR VPWR _0900_ sky130_fd_sc_hd__mux2_1
X_2153_ _0812_ VGND VGND VPWR VPWR _0847_ sky130_fd_sc_hd__buf_4
XFILLER_0_17_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_88_441 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2084_ _0794_ VGND VGND VPWR VPWR net138 sky130_fd_sc_hd__buf_1
XFILLER_0_29_541 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_33_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_44_522 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_44_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_56_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2986_ _1431_ VGND VGND VPWR VPWR _0258_ sky130_fd_sc_hd__clkbuf_1
X_4656_ clknet_leaf_20_clk _0696_ VGND VGND VPWR VPWR instance_2.data\[3\]\[48\] sky130_fd_sc_hd__dfxtp_1
X_4587_ clknet_leaf_17_clk _0627_ VGND VGND VPWR VPWR instance_1.data\[0\]\[51\] sky130_fd_sc_hd__dfxtp_1
Xinput70 wdata[6] VGND VGND VPWR VPWR net70 sky130_fd_sc_hd__buf_1
X_3607_ _0977_ net419 _1748_ VGND VGND VPWR VPWR _1758_ sky130_fd_sc_hd__mux2_1
X_3538_ _0865_ net760 _1715_ VGND VGND VPWR VPWR _1722_ sky130_fd_sc_hd__mux2_1
X_3469_ net341 _1247_ _1680_ VGND VGND VPWR VPWR _1686_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_55_723 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_27_458 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_22_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_62_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_57_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_85_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_45_308 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_57_146 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2840_ net767 _0968_ _1347_ VGND VGND VPWR VPWR _1354_ sky130_fd_sc_hd__mux2_1
X_2771_ net651 _0857_ _1314_ VGND VGND VPWR VPWR _1318_ sky130_fd_sc_hd__mux2_1
XFILLER_0_26_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4510_ clknet_leaf_25_clk _0550_ VGND VGND VPWR VPWR instance_2.rdata\[46\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_13_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xhold117 instance_1.data\[3\]\[37\] VGND VGND VPWR VPWR net267 sky130_fd_sc_hd__dlygate4sd3_1
X_4441_ clknet_leaf_17_clk _0481_ VGND VGND VPWR VPWR instance_1.data\[2\]\[49\] sky130_fd_sc_hd__dfxtp_1
Xhold106 instance_2.data\[2\]\[16\] VGND VGND VPWR VPWR net256 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_41_547 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_9_Right_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold139 instance_1.rdata\[2\] VGND VGND VPWR VPWR net289 sky130_fd_sc_hd__dlygate4sd3_1
Xhold128 instance_1.data\[1\]\[9\] VGND VGND VPWR VPWR net278 sky130_fd_sc_hd__dlygate4sd3_1
X_4372_ clknet_leaf_20_clk _0412_ VGND VGND VPWR VPWR instance_1.rdata\[52\] sky130_fd_sc_hd__dfxtp_1
X_3323_ net506 _1255_ _1600_ VGND VGND VPWR VPWR _1609_ sky130_fd_sc_hd__mux2_1
X_3254_ net261 _1144_ _1567_ VGND VGND VPWR VPWR _1573_ sky130_fd_sc_hd__mux2_1
XFILLER_0_28_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2205_ _0886_ net18 _0876_ VGND VGND VPWR VPWR _0887_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_69_859 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3185_ _1536_ VGND VGND VPWR VPWR _0352_ sky130_fd_sc_hd__clkbuf_1
X_2136_ _0833_ VGND VGND VPWR VPWR _0006_ sky130_fd_sc_hd__clkbuf_1
X_2067_ _0785_ VGND VGND VPWR VPWR net129 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_88_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_76_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_24_428 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_91_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2969_ _1422_ VGND VGND VPWR VPWR _0250_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_29_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_44_330 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_60_770 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_44_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_44_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4639_ clknet_leaf_32_clk _0679_ VGND VGND VPWR VPWR instance_2.data\[3\]\[31\] sky130_fd_sc_hd__dfxtp_1
Xhold640 instance_2.rdata\[8\] VGND VGND VPWR VPWR net790 sky130_fd_sc_hd__dlygate4sd3_1
Xhold651 instance_2.data\[0\]\[1\] VGND VGND VPWR VPWR net801 sky130_fd_sc_hd__dlygate4sd3_1
Xhold662 instance_1.data\[2\]\[11\] VGND VGND VPWR VPWR net812 sky130_fd_sc_hd__dlygate4sd3_1
Xhold684 instance_1.data\[3\]\[35\] VGND VGND VPWR VPWR net834 sky130_fd_sc_hd__dlygate4sd3_1
Xhold695 instance_2.data\[2\]\[44\] VGND VGND VPWR VPWR net845 sky130_fd_sc_hd__dlygate4sd3_1
Xhold673 instance_2.rdata\[32\] VGND VGND VPWR VPWR net823 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_39_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_67_422 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_39_146 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_67_455 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_62_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_2_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_50_355 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_4_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_66_829 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_81_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_85_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_14_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3941_ _1934_ VGND VGND VPWR VPWR _0710_ sky130_fd_sc_hd__clkbuf_1
X_3872_ _1864_ VGND VGND VPWR VPWR _1898_ sky130_fd_sc_hd__buf_4
X_2823_ net252 _0941_ _1336_ VGND VGND VPWR VPWR _1345_ sky130_fd_sc_hd__mux2_1
X_2754_ net299 _0829_ _1303_ VGND VGND VPWR VPWR _1309_ sky130_fd_sc_hd__mux2_1
XFILLER_0_83_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_41_322 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_76_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2685_ _0803_ VGND VGND VPWR VPWR _1258_ sky130_fd_sc_hd__buf_4
XFILLER_0_1_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4424_ clknet_leaf_33_clk _0464_ VGND VGND VPWR VPWR instance_1.data\[2\]\[32\] sky130_fd_sc_hd__dfxtp_1
X_4355_ clknet_leaf_30_clk _0395_ VGND VGND VPWR VPWR instance_1.rdata\[35\] sky130_fd_sc_hd__dfxtp_1
X_3306_ _1544_ VGND VGND VPWR VPWR _1600_ sky130_fd_sc_hd__clkbuf_4
X_4286_ clknet_leaf_27_clk _0326_ VGND VGND VPWR VPWR instance_1.data\[3\]\[38\] sky130_fd_sc_hd__dfxtp_1
X_3237_ net561 _1116_ _1556_ VGND VGND VPWR VPWR _1564_ sky130_fd_sc_hd__mux2_1
X_3168_ _1527_ VGND VGND VPWR VPWR _0344_ sky130_fd_sc_hd__clkbuf_1
X_2119_ _0820_ VGND VGND VPWR VPWR _0002_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_68_208 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_37_553 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3099_ _1491_ VGND VGND VPWR VPWR _0311_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_49_499 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_91_233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_91_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_8_Left_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold470 instance_1.data\[0\]\[10\] VGND VGND VPWR VPWR net620 sky130_fd_sc_hd__dlygate4sd3_1
Xhold481 instance_2.data\[2\]\[47\] VGND VGND VPWR VPWR net631 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_9_289 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xhold492 instance_1.data\[2\]\[7\] VGND VGND VPWR VPWR net642 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_87_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_71_876 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_82_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_50_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_11_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2470_ instance_1.data\[0\]\[10\] instance_1.data\[1\]\[10\] instance_1.data\[2\]\[10\]
+ instance_1.data\[3\]\[10\] _1075_ _1088_ VGND VGND VPWR VPWR _1092_ sky130_fd_sc_hd__mux4_1
XFILLER_0_23_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_76_14 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_76_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4140_ clknet_leaf_29_clk _0180_ VGND VGND VPWR VPWR instance_2.data\[1\]\[36\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_76_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_79_954 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4071_ clknet_leaf_28_clk _0111_ VGND VGND VPWR VPWR instance_1.data\[1\]\[39\] sky130_fd_sc_hd__dfxtp_1
X_3022_ _1383_ VGND VGND VPWR VPWR _1450_ sky130_fd_sc_hd__buf_4
XFILLER_0_92_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_34_523 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3924_ _1925_ VGND VGND VPWR VPWR _0702_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_6_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3855_ _1889_ VGND VGND VPWR VPWR _0669_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_46_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_61_417 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3786_ _1852_ VGND VGND VPWR VPWR _0637_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_54_480 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2806_ _1302_ VGND VGND VPWR VPWR _1336_ sky130_fd_sc_hd__buf_4
X_2737_ net72 _1297_ _0806_ VGND VGND VPWR VPWR _1298_ sky130_fd_sc_hd__mux2_1
X_2668_ _0801_ VGND VGND VPWR VPWR _1245_ sky130_fd_sc_hd__buf_4
X_4407_ clknet_leaf_47_clk _0447_ VGND VGND VPWR VPWR instance_1.data\[2\]\[15\] sky130_fd_sc_hd__dfxtp_1
X_2599_ net36 _1191_ _1165_ VGND VGND VPWR VPWR _1192_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_6_259 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4338_ clknet_leaf_43_clk _0378_ VGND VGND VPWR VPWR instance_1.rdata\[18\] sky130_fd_sc_hd__dfxtp_1
X_4269_ clknet_leaf_42_clk _0309_ VGND VGND VPWR VPWR instance_1.data\[3\]\[21\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_52_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_76_924 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_86_1020 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_48_659 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_62_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1970_ instance_1.rdata\[11\] instance_2.rdata\[11\] _0733_ VGND VGND VPWR VPWR _0735_
+ sky130_fd_sc_hd__mux2_1
XFILLER_0_3_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3640_ _1775_ VGND VGND VPWR VPWR _0568_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_70_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3571_ _1739_ VGND VGND VPWR VPWR _0535_ sky130_fd_sc_hd__clkbuf_1
X_2522_ net317 _1132_ _1128_ VGND VGND VPWR VPWR _1133_ sky130_fd_sc_hd__mux2_1
XFILLER_0_87_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2453_ instance_1.data\[0\]\[6\] instance_1.data\[1\]\[6\] instance_1.data\[2\]\[6\]
+ instance_1.data\[3\]\[6\] _1075_ _1054_ VGND VGND VPWR VPWR _1079_ sky130_fd_sc_hd__mux4_1
X_2384_ net1 VGND VGND VPWR VPWR _1025_ sky130_fd_sc_hd__buf_4
X_4123_ clknet_leaf_52_clk _0163_ VGND VGND VPWR VPWR instance_2.data\[1\]\[19\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_3_229 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4054_ clknet_leaf_41_clk _0094_ VGND VGND VPWR VPWR instance_1.data\[1\]\[22\] sky130_fd_sc_hd__dfxtp_1
Xinput2 address[1] VGND VGND VPWR VPWR net2 sky130_fd_sc_hd__buf_2
X_3005_ _1441_ VGND VGND VPWR VPWR _0267_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_78_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_19_383 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_19_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_19_458 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3907_ _1916_ VGND VGND VPWR VPWR _0694_ sky130_fd_sc_hd__clkbuf_1
X_3838_ _1880_ VGND VGND VPWR VPWR _0661_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_61_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_6_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3769_ _1843_ VGND VGND VPWR VPWR _0629_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_42_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_45_629 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_69_369 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_81_971 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_40_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_0_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_87_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_16_353 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_90_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1953_ instance_1.rdata\[3\] instance_2.rdata\[3\] _0722_ VGND VGND VPWR VPWR _0726_
+ sky130_fd_sc_hd__mux2_1
XFILLER_0_22_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_43_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4672_ clknet_leaf_9_clk _0712_ VGND VGND VPWR VPWR instance_2.data\[3\]\[64\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_31_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_43_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3623_ _1766_ VGND VGND VPWR VPWR _0560_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_3_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_24_494 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3554_ _1730_ VGND VGND VPWR VPWR _0527_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_11_155 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2505_ instance_1.data\[0\]\[18\] instance_1.data\[1\]\[18\] instance_1.data\[2\]\[18\]
+ instance_1.data\[3\]\[18\] _1109_ _1088_ VGND VGND VPWR VPWR _1119_ sky130_fd_sc_hd__mux4_1
X_3485_ _1694_ VGND VGND VPWR VPWR _0494_ sky130_fd_sc_hd__clkbuf_1
X_2436_ instance_1.data\[0\]\[2\] instance_1.data\[1\]\[2\] instance_1.data\[2\]\[2\]
+ instance_1.data\[3\]\[2\] _0808_ _1054_ VGND VGND VPWR VPWR _1066_ sky130_fd_sc_hd__mux4_1
X_2367_ _0720_ VGND VGND VPWR VPWR _1012_ sky130_fd_sc_hd__buf_4
X_4106_ clknet_leaf_62_clk _0146_ VGND VGND VPWR VPWR instance_2.data\[1\]\[2\] sky130_fd_sc_hd__dfxtp_1
X_2298_ _0958_ net41 _0944_ VGND VGND VPWR VPWR _0959_ sky130_fd_sc_hd__mux2_1
XFILLER_0_78_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4037_ clknet_leaf_55_clk _0077_ VGND VGND VPWR VPWR instance_1.data\[1\]\[5\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_62_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_50_676 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_30_453 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_58_754 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_38_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_13_323 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_25_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_92_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_80_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_53_545 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_40_228 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_21_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3270_ _1581_ VGND VGND VPWR VPWR _0392_ sky130_fd_sc_hd__clkbuf_1
X_2221_ instance_2.data\[0\]\[26\] instance_2.data\[1\]\[26\] instance_2.data\[2\]\[26\]
+ instance_2.data\[3\]\[26\] _0889_ _0868_ VGND VGND VPWR VPWR _0899_ sky130_fd_sc_hd__mux4_1
X_2152_ _0845_ net5 _0842_ VGND VGND VPWR VPWR _0846_ sky130_fd_sc_hd__mux2_1
X_2083_ instance_1.rdata\[65\] instance_2.rdata\[65\] _0788_ VGND VGND VPWR VPWR _0794_
+ sky130_fd_sc_hd__mux2_1
XFILLER_0_88_453 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_75_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_90_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_56_383 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2985_ _0955_ net785 _1428_ VGND VGND VPWR VPWR _1431_ sky130_fd_sc_hd__mux2_1
XFILLER_0_44_545 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4655_ clknet_leaf_21_clk _0695_ VGND VGND VPWR VPWR instance_2.data\[3\]\[47\] sky130_fd_sc_hd__dfxtp_1
X_4586_ clknet_leaf_18_clk _0626_ VGND VGND VPWR VPWR instance_1.data\[0\]\[50\] sky130_fd_sc_hd__dfxtp_1
X_3606_ _1757_ VGND VGND VPWR VPWR _0552_ sky130_fd_sc_hd__clkbuf_1
Xinput71 wdata[70] VGND VGND VPWR VPWR net71 sky130_fd_sc_hd__buf_1
Xinput60 wdata[60] VGND VGND VPWR VPWR net60 sky130_fd_sc_hd__buf_1
X_3537_ _1721_ VGND VGND VPWR VPWR _0519_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_12_486 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3468_ _1685_ VGND VGND VPWR VPWR _0486_ sky130_fd_sc_hd__clkbuf_1
X_3399_ _1649_ VGND VGND VPWR VPWR _0453_ sky130_fd_sc_hd__clkbuf_1
X_2419_ _1051_ net72 _1045_ VGND VGND VPWR VPWR _1052_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_55_724 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_27_459 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_54_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_50_504 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_26_Left_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_38_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_35_Left_128 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_70_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_38_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_72_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2770_ _1317_ VGND VGND VPWR VPWR _0156_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_26_545 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4440_ clknet_leaf_18_clk _0480_ VGND VGND VPWR VPWR instance_1.data\[2\]\[48\] sky130_fd_sc_hd__dfxtp_1
Xhold107 instance_1.data\[2\]\[15\] VGND VGND VPWR VPWR net257 sky130_fd_sc_hd__dlygate4sd3_1
XPHY_EDGE_ROW_44_Left_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold118 instance_1.rdata\[41\] VGND VGND VPWR VPWR net268 sky130_fd_sc_hd__dlygate4sd3_1
Xhold129 instance_1.data\[0\]\[3\] VGND VGND VPWR VPWR net279 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_0_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4371_ clknet_leaf_16_clk _0411_ VGND VGND VPWR VPWR instance_1.rdata\[51\] sky130_fd_sc_hd__dfxtp_1
X_3322_ _1608_ VGND VGND VPWR VPWR _0417_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_0_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3253_ _1572_ VGND VGND VPWR VPWR _0384_ sky130_fd_sc_hd__clkbuf_1
X_2204_ instance_2.data\[0\]\[22\] instance_2.data\[1\]\[22\] instance_2.data\[2\]\[22\]
+ instance_2.data\[3\]\[22\] _0855_ _0868_ VGND VGND VPWR VPWR _0886_ sky130_fd_sc_hd__mux4_1
X_3184_ net742 _1277_ _1531_ VGND VGND VPWR VPWR _1536_ sky130_fd_sc_hd__mux2_1
X_2135_ net241 _0832_ _0813_ VGND VGND VPWR VPWR _0833_ sky130_fd_sc_hd__mux2_1
XPHY_EDGE_ROW_53_Left_146 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2066_ instance_1.rdata\[57\] instance_2.rdata\[57\] _0777_ VGND VGND VPWR VPWR _0785_
+ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_24_429 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2968_ _0928_ net797 _1417_ VGND VGND VPWR VPWR _1422_ sky130_fd_sc_hd__mux2_1
XFILLER_0_44_342 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_60_771 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_62_Left_155 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2899_ _0816_ net801 _1384_ VGND VGND VPWR VPWR _1386_ sky130_fd_sc_hd__mux2_1
X_4638_ clknet_leaf_36_clk _0678_ VGND VGND VPWR VPWR instance_2.data\[3\]\[30\] sky130_fd_sc_hd__dfxtp_1
Xhold630 instance_2.data\[0\]\[66\] VGND VGND VPWR VPWR net780 sky130_fd_sc_hd__dlygate4sd3_1
X_4569_ clknet_leaf_31_clk _0609_ VGND VGND VPWR VPWR instance_1.data\[0\]\[33\] sky130_fd_sc_hd__dfxtp_1
Xhold641 instance_1.data\[1\]\[64\] VGND VGND VPWR VPWR net791 sky130_fd_sc_hd__dlygate4sd3_1
Xhold652 instance_2.data\[3\]\[68\] VGND VGND VPWR VPWR net802 sky130_fd_sc_hd__dlygate4sd3_1
Xhold663 instance_2.rdata\[43\] VGND VGND VPWR VPWR net813 sky130_fd_sc_hd__dlygate4sd3_1
Xhold696 instance_2.data\[0\]\[4\] VGND VGND VPWR VPWR net846 sky130_fd_sc_hd__dlygate4sd3_1
Xhold685 instance_2.data\[0\]\[31\] VGND VGND VPWR VPWR net835 sky130_fd_sc_hd__dlygate4sd3_1
Xhold674 instance_2.data\[0\]\[33\] VGND VGND VPWR VPWR net824 sky130_fd_sc_hd__dlygate4sd3_1
XPHY_EDGE_ROW_71_Left_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_82_448 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_80_Left_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_50_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_81_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_77_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3940_ net313 _1023_ _1931_ VGND VGND VPWR VPWR _1934_ sky130_fd_sc_hd__mux2_1
XFILLER_0_14_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3871_ _1897_ VGND VGND VPWR VPWR _0677_ sky130_fd_sc_hd__clkbuf_1
X_2822_ _1344_ VGND VGND VPWR VPWR _0181_ sky130_fd_sc_hd__clkbuf_1
X_2753_ _1308_ VGND VGND VPWR VPWR _0148_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_5_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_81_481 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2684_ _1257_ VGND VGND VPWR VPWR _0130_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_30_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4423_ clknet_leaf_33_clk _0463_ VGND VGND VPWR VPWR instance_1.data\[2\]\[31\] sky130_fd_sc_hd__dfxtp_1
X_4354_ clknet_leaf_31_clk _0394_ VGND VGND VPWR VPWR instance_1.rdata\[34\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_1_486 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3305_ _1599_ VGND VGND VPWR VPWR _0409_ sky130_fd_sc_hd__clkbuf_1
X_4285_ clknet_leaf_28_clk _0325_ VGND VGND VPWR VPWR instance_1.data\[3\]\[37\] sky130_fd_sc_hd__dfxtp_1
X_3236_ _1563_ VGND VGND VPWR VPWR _0376_ sky130_fd_sc_hd__clkbuf_1
X_3167_ net557 _1250_ _1520_ VGND VGND VPWR VPWR _1527_ sky130_fd_sc_hd__mux2_1
X_2118_ net193 _0819_ _0813_ VGND VGND VPWR VPWR _0820_ sky130_fd_sc_hd__mux2_1
X_3098_ net510 _1138_ _1487_ VGND VGND VPWR VPWR _1491_ sky130_fd_sc_hd__mux2_1
XFILLER_0_55_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2049_ instance_1.rdata\[49\] instance_2.rdata\[49\] _0766_ VGND VGND VPWR VPWR _0776_
+ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_37_554 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_91_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_36_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold471 instance_2.data\[1\]\[69\] VGND VGND VPWR VPWR net621 sky130_fd_sc_hd__dlygate4sd3_1
Xhold460 instance_2.data\[1\]\[44\] VGND VGND VPWR VPWR net610 sky130_fd_sc_hd__dlygate4sd3_1
Xhold482 instance_2.rdata\[64\] VGND VGND VPWR VPWR net632 sky130_fd_sc_hd__dlygate4sd3_1
Xhold493 instance_2.data\[3\]\[64\] VGND VGND VPWR VPWR net643 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_87_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_0_190 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_82_212 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_71_877 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_27_128 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_70_418 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_23_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_70_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_23_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_11_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_50_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_76_59 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4070_ clknet_leaf_28_clk _0110_ VGND VGND VPWR VPWR instance_1.data\[1\]\[38\] sky130_fd_sc_hd__dfxtp_1
X_3021_ _1449_ VGND VGND VPWR VPWR _0275_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_92_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_86_551 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_34_524 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_58_231 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_58_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_73_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_58_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3923_ net203 _0996_ _1920_ VGND VGND VPWR VPWR _1925_ sky130_fd_sc_hd__mux2_1
XFILLER_0_73_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_18_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3854_ net758 _0884_ _1887_ VGND VGND VPWR VPWR _1889_ sky130_fd_sc_hd__mux2_1
XFILLER_0_73_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_6_545 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2805_ _1335_ VGND VGND VPWR VPWR _0173_ sky130_fd_sc_hd__clkbuf_1
X_3785_ net726 _1268_ _1850_ VGND VGND VPWR VPWR _1852_ sky130_fd_sc_hd__mux2_1
XFILLER_0_41_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2736_ instance_1.data\[0\]\[71\] instance_1.data\[1\]\[71\] instance_1.data\[2\]\[71\]
+ instance_1.data\[3\]\[71\] _0802_ _0804_ VGND VGND VPWR VPWR _1297_ sky130_fd_sc_hd__mux4_1
X_2667_ _1244_ VGND VGND VPWR VPWR _0126_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_1_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4406_ clknet_leaf_45_clk _0446_ VGND VGND VPWR VPWR instance_1.data\[2\]\[14\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_67_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2598_ instance_1.data\[0\]\[39\] instance_1.data\[1\]\[39\] instance_1.data\[2\]\[39\]
+ instance_1.data\[3\]\[39\] _1177_ _1190_ VGND VGND VPWR VPWR _1191_ sky130_fd_sc_hd__mux4_1
XFILLER_0_10_551 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_5_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4337_ clknet_leaf_43_clk _0377_ VGND VGND VPWR VPWR instance_1.rdata\[17\] sky130_fd_sc_hd__dfxtp_1
X_4268_ clknet_leaf_40_clk _0308_ VGND VGND VPWR VPWR instance_1.data\[3\]\[20\] sky130_fd_sc_hd__dfxtp_1
X_3219_ _1554_ VGND VGND VPWR VPWR _0368_ sky130_fd_sc_hd__clkbuf_1
X_4199_ clknet_leaf_39_clk _0239_ VGND VGND VPWR VPWR instance_2.data\[0\]\[23\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_49_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_49_264 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_20_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold290 instance_2.data\[1\]\[39\] VGND VGND VPWR VPWR net440 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_46_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_76_925 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_86_1021 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_28_448 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_55_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_70_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3570_ _0917_ net707 _1737_ VGND VGND VPWR VPWR _1739_ sky130_fd_sc_hd__mux2_1
XFILLER_0_11_98 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_87 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2521_ net17 _1130_ _1131_ VGND VGND VPWR VPWR _1132_ sky130_fd_sc_hd__mux2_1
XFILLER_0_11_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_87_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2452_ _1078_ VGND VGND VPWR VPWR _0077_ sky130_fd_sc_hd__clkbuf_1
XPHY_EDGE_ROW_18_Right_18 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2383_ _1024_ VGND VGND VPWR VPWR _0062_ sky130_fd_sc_hd__clkbuf_1
X_4122_ clknet_leaf_51_clk _0162_ VGND VGND VPWR VPWR instance_2.data\[1\]\[18\] sky130_fd_sc_hd__dfxtp_1
X_4053_ clknet_leaf_42_clk _0093_ VGND VGND VPWR VPWR instance_1.data\[1\]\[21\] sky130_fd_sc_hd__dfxtp_1
Xinput3 address[2] VGND VGND VPWR VPWR net3 sky130_fd_sc_hd__dlymetal6s2s_1
X_3004_ _0986_ net528 _1439_ VGND VGND VPWR VPWR _1441_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_19_384 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_27_Right_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_46_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_46_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3906_ net652 _0968_ _1909_ VGND VGND VPWR VPWR _1916_ sky130_fd_sc_hd__mux2_1
X_3837_ net757 _0857_ _1876_ VGND VGND VPWR VPWR _1880_ sky130_fd_sc_hd__mux2_1
X_3768_ net333 _1240_ _1839_ VGND VGND VPWR VPWR _1843_ sky130_fd_sc_hd__mux2_1
X_2719_ _1284_ VGND VGND VPWR VPWR _0138_ sky130_fd_sc_hd__clkbuf_1
X_3699_ net517 _1127_ _1806_ VGND VGND VPWR VPWR _1807_ sky130_fd_sc_hd__mux2_1
XPHY_EDGE_ROW_36_Right_36 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_45_Right_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_69_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_81_972 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_77_370 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_37_212 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_65_532 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_80_546 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_0_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_54_Right_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_92_1080 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_63_Right_63 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_87_156 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_75_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_16_354 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_28_201 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1952_ _0725_ VGND VGND VPWR VPWR net99 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_7_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_22_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4671_ clknet_leaf_9_clk _0711_ VGND VGND VPWR VPWR instance_2.data\[3\]\[63\] sky130_fd_sc_hd__dfxtp_1
X_3622_ _1001_ net839 _1759_ VGND VGND VPWR VPWR _1766_ sky130_fd_sc_hd__mux2_1
XPHY_EDGE_ROW_72_Right_72 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3553_ _0890_ net809 _1726_ VGND VGND VPWR VPWR _1730_ sky130_fd_sc_hd__mux2_1
X_2504_ _1118_ VGND VGND VPWR VPWR _0089_ sky130_fd_sc_hd__clkbuf_1
X_3484_ net778 _1271_ _1691_ VGND VGND VPWR VPWR _1694_ sky130_fd_sc_hd__mux2_1
XFILLER_0_11_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2435_ _1065_ VGND VGND VPWR VPWR _0073_ sky130_fd_sc_hd__clkbuf_1
X_4105_ clknet_leaf_0_clk _0145_ VGND VGND VPWR VPWR instance_2.data\[1\]\[1\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_47_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2366_ instance_2.data\[0\]\[59\] instance_2.data\[1\]\[59\] instance_2.data\[2\]\[59\]
+ instance_2.data\[3\]\[59\] _0991_ _1004_ VGND VGND VPWR VPWR _1011_ sky130_fd_sc_hd__mux4_1
XPHY_EDGE_ROW_81_Right_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2297_ instance_2.data\[0\]\[43\] instance_2.data\[1\]\[43\] instance_2.data\[2\]\[43\]
+ instance_2.data\[3\]\[43\] _0957_ _0936_ VGND VGND VPWR VPWR _0958_ sky130_fd_sc_hd__mux4_1
XFILLER_0_78_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_2_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4036_ clknet_leaf_58_clk _0076_ VGND VGND VPWR VPWR instance_1.data\[1\]\[4\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_78_156 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_78_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_59_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_74_384 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_74_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_90_Right_90 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_50_677 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_6_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_30_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_58_755 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_57_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_13_324 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_65_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_92_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_25_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_33_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2220_ _0898_ VGND VGND VPWR VPWR _0025_ sky130_fd_sc_hd__clkbuf_1
X_2151_ instance_2.data\[0\]\[10\] instance_2.data\[1\]\[10\] instance_2.data\[2\]\[10\]
+ instance_2.data\[3\]\[10\] _0821_ _0834_ VGND VGND VPWR VPWR _0845_ sky130_fd_sc_hd__mux4_1
X_2082_ _0793_ VGND VGND VPWR VPWR net137 sky130_fd_sc_hd__buf_1
XFILLER_0_88_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_48_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_33_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2984_ _1430_ VGND VGND VPWR VPWR _0257_ sky130_fd_sc_hd__clkbuf_1
X_4654_ clknet_leaf_21_clk _0694_ VGND VGND VPWR VPWR instance_2.data\[3\]\[46\] sky130_fd_sc_hd__dfxtp_1
Xinput50 wdata[51] VGND VGND VPWR VPWR net50 sky130_fd_sc_hd__buf_1
X_4585_ clknet_leaf_19_clk _0625_ VGND VGND VPWR VPWR instance_1.data\[0\]\[49\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_12_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xinput72 wdata[71] VGND VGND VPWR VPWR net72 sky130_fd_sc_hd__buf_1
Xinput61 wdata[61] VGND VGND VPWR VPWR net61 sky130_fd_sc_hd__buf_1
X_3605_ _0974_ net844 _1748_ VGND VGND VPWR VPWR _1757_ sky130_fd_sc_hd__mux2_1
X_3536_ _0862_ net792 _1715_ VGND VGND VPWR VPWR _1721_ sky130_fd_sc_hd__mux2_1
XFILLER_0_12_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3467_ net571 _1243_ _1680_ VGND VGND VPWR VPWR _1685_ sky130_fd_sc_hd__mux2_1
X_3398_ net262 _1132_ _1647_ VGND VGND VPWR VPWR _1649_ sky130_fd_sc_hd__mux2_1
X_2418_ instance_2.data\[0\]\[71\] instance_2.data\[1\]\[71\] instance_2.data\[2\]\[71\]
+ instance_2.data\[3\]\[71\] _1025_ _0809_ VGND VGND VPWR VPWR _1051_ sky130_fd_sc_hd__mux4_1
X_2349_ instance_2.data\[0\]\[55\] instance_2.data\[1\]\[55\] instance_2.data\[2\]\[55\]
+ instance_2.data\[3\]\[55\] _0991_ _0970_ VGND VGND VPWR VPWR _0998_ sky130_fd_sc_hd__mux4_1
XFILLER_0_79_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_55_725 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4019_ clknet_leaf_10_clk _0059_ VGND VGND VPWR VPWR instance_2.data\[2\]\[59\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_79_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_79_498 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_0_Right_0 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_66_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_22_207 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_50_516 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_62_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_30_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_38_384 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_41_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold108 instance_1.rdata\[51\] VGND VGND VPWR VPWR net258 sky130_fd_sc_hd__dlygate4sd3_1
X_4370_ clknet_leaf_19_clk _0410_ VGND VGND VPWR VPWR instance_1.rdata\[50\] sky130_fd_sc_hd__dfxtp_1
Xhold119 instance_1.rdata\[63\] VGND VGND VPWR VPWR net269 sky130_fd_sc_hd__dlygate4sd3_1
X_3321_ net692 _1252_ _1600_ VGND VGND VPWR VPWR _1608_ sky130_fd_sc_hd__mux2_1
XFILLER_0_0_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3252_ net292 _1140_ _1567_ VGND VGND VPWR VPWR _1572_ sky130_fd_sc_hd__mux2_1
X_3183_ _1535_ VGND VGND VPWR VPWR _0351_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_28_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2203_ _0885_ VGND VGND VPWR VPWR _0021_ sky130_fd_sc_hd__clkbuf_1
X_2134_ _0831_ net70 _0806_ VGND VGND VPWR VPWR _0832_ sky130_fd_sc_hd__mux2_1
XFILLER_0_88_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2065_ _0784_ VGND VGND VPWR VPWR net128 sky130_fd_sc_hd__buf_1
XFILLER_0_91_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_91_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2967_ _1421_ VGND VGND VPWR VPWR _0249_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_56_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_60_772 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2898_ _1385_ VGND VGND VPWR VPWR _0216_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_44_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_60_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4637_ clknet_leaf_37_clk _0677_ VGND VGND VPWR VPWR instance_2.data\[3\]\[29\] sky130_fd_sc_hd__dfxtp_1
Xhold620 instance_2.data\[0\]\[71\] VGND VGND VPWR VPWR net770 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_12_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold642 instance_2.rdata\[15\] VGND VGND VPWR VPWR net792 sky130_fd_sc_hd__dlygate4sd3_1
Xhold653 instance_2.data\[0\]\[17\] VGND VGND VPWR VPWR net803 sky130_fd_sc_hd__dlygate4sd3_1
Xhold631 instance_2.rdata\[65\] VGND VGND VPWR VPWR net781 sky130_fd_sc_hd__dlygate4sd3_1
X_4568_ clknet_leaf_33_clk _0608_ VGND VGND VPWR VPWR instance_1.data\[0\]\[32\] sky130_fd_sc_hd__dfxtp_1
Xhold675 instance_2.rdata\[34\] VGND VGND VPWR VPWR net825 sky130_fd_sc_hd__dlygate4sd3_1
X_4499_ clknet_leaf_29_clk _0539_ VGND VGND VPWR VPWR instance_2.rdata\[35\] sky130_fd_sc_hd__dfxtp_1
X_3519_ _0835_ net751 _1704_ VGND VGND VPWR VPWR _1712_ sky130_fd_sc_hd__mux2_1
Xhold697 instance_2.data\[0\]\[19\] VGND VGND VPWR VPWR net847 sky130_fd_sc_hd__dlygate4sd3_1
Xhold686 instance_1.data\[1\]\[63\] VGND VGND VPWR VPWR net836 sky130_fd_sc_hd__dlygate4sd3_1
Xhold664 instance_2.rdata\[71\] VGND VGND VPWR VPWR net814 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_85_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_68_850 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_23_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_leaf_20_clk clknet_3_3__leaf_clk VGND VGND VPWR VPWR clknet_leaf_20_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_0_23_549 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_65_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_89_1041 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_85_287 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3870_ net646 _0911_ _1887_ VGND VGND VPWR VPWR _1897_ sky130_fd_sc_hd__mux2_1
X_2821_ net171 _0938_ _1336_ VGND VGND VPWR VPWR _1344_ sky130_fd_sc_hd__mux2_1
X_2752_ net654 _0826_ _1303_ VGND VGND VPWR VPWR _1308_ sky130_fd_sc_hd__mux2_1
Xclkbuf_leaf_11_clk clknet_3_2__leaf_clk VGND VGND VPWR VPWR clknet_leaf_11_clk sky130_fd_sc_hd__clkbuf_8
X_2683_ net358 _1256_ _1230_ VGND VGND VPWR VPWR _1257_ sky130_fd_sc_hd__mux2_1
X_4422_ clknet_leaf_35_clk _0462_ VGND VGND VPWR VPWR instance_1.data\[2\]\[30\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_1_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4353_ clknet_leaf_31_clk _0393_ VGND VGND VPWR VPWR instance_1.rdata\[33\] sky130_fd_sc_hd__dfxtp_1
X_4284_ clknet_leaf_30_clk _0324_ VGND VGND VPWR VPWR instance_1.data\[3\]\[36\] sky130_fd_sc_hd__dfxtp_1
X_3304_ net439 _1225_ _1589_ VGND VGND VPWR VPWR _1599_ sky130_fd_sc_hd__mux2_1
XFILLER_0_1_498 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3235_ net368 _1113_ _1556_ VGND VGND VPWR VPWR _1563_ sky130_fd_sc_hd__mux2_1
X_3166_ _1526_ VGND VGND VPWR VPWR _0343_ sky130_fd_sc_hd__clkbuf_1
X_2117_ _0818_ net26 _0806_ VGND VGND VPWR VPWR _0819_ sky130_fd_sc_hd__mux2_1
X_3097_ _1490_ VGND VGND VPWR VPWR _0310_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_65_820 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2048_ _0775_ VGND VGND VPWR VPWR net119 sky130_fd_sc_hd__buf_1
XFILLER_0_12_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_37_555 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_49_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_36_107 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_76_298 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_36_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3999_ clknet_leaf_23_clk _0039_ VGND VGND VPWR VPWR instance_2.data\[2\]\[39\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_32_324 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_44_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_32_346 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold450 instance_2.rdata\[60\] VGND VGND VPWR VPWR net600 sky130_fd_sc_hd__dlygate4sd3_1
Xhold461 instance_2.data\[0\]\[61\] VGND VGND VPWR VPWR net611 sky130_fd_sc_hd__dlygate4sd3_1
Xhold472 instance_2.data\[0\]\[30\] VGND VGND VPWR VPWR net622 sky130_fd_sc_hd__dlygate4sd3_1
Xhold483 instance_1.data\[2\]\[34\] VGND VGND VPWR VPWR net633 sky130_fd_sc_hd__dlygate4sd3_1
Xhold494 instance_2.data\[3\]\[67\] VGND VGND VPWR VPWR net644 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_0_191 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_51_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_67_254 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_71_878 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_67_298 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_2_207 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_23_346 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_50_110 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_8_280 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_92_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_leaf_0_clk clknet_3_0__leaf_clk VGND VGND VPWR VPWR clknet_leaf_0_clk sky130_fd_sc_hd__clkbuf_8
X_3020_ _1013_ net816 _1439_ VGND VGND VPWR VPWR _1449_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_34_525 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3922_ _1924_ VGND VGND VPWR VPWR _0701_ sky130_fd_sc_hd__clkbuf_1
X_3853_ _1888_ VGND VGND VPWR VPWR _0668_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_73_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2804_ net669 _0911_ _1325_ VGND VGND VPWR VPWR _1335_ sky130_fd_sc_hd__mux2_1
X_3784_ _1851_ VGND VGND VPWR VPWR _0636_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_26_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2735_ _1296_ VGND VGND VPWR VPWR _0142_ sky130_fd_sc_hd__clkbuf_1
X_2666_ net732 _1243_ _1230_ VGND VGND VPWR VPWR _1244_ sky130_fd_sc_hd__mux2_1
XFILLER_0_10_530 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4405_ clknet_leaf_45_clk _0445_ VGND VGND VPWR VPWR instance_1.data\[2\]\[13\] sky130_fd_sc_hd__dfxtp_1
X_2597_ _0803_ VGND VGND VPWR VPWR _1190_ sky130_fd_sc_hd__clkbuf_4
X_4336_ clknet_leaf_47_clk _0376_ VGND VGND VPWR VPWR instance_1.rdata\[16\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_5_96 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4267_ clknet_leaf_43_clk _0307_ VGND VGND VPWR VPWR instance_1.data\[3\]\[19\] sky130_fd_sc_hd__dfxtp_1
X_3218_ net301 _1085_ _1545_ VGND VGND VPWR VPWR _1554_ sky130_fd_sc_hd__mux2_1
X_4198_ clknet_leaf_52_clk _0238_ VGND VGND VPWR VPWR instance_2.data\[0\]\[22\] sky130_fd_sc_hd__dfxtp_1
X_3149_ _1517_ VGND VGND VPWR VPWR _0335_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_92_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_37_449 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold280 instance_2.data\[3\]\[1\] VGND VGND VPWR VPWR net430 sky130_fd_sc_hd__dlygate4sd3_1
Xhold291 instance_1.rdata\[14\] VGND VGND VPWR VPWR net441 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_1_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_76_926 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_5_250 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_62_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_68_541 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_70_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_11_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_36_493 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_87_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_11_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_51_474 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2520_ _1045_ VGND VGND VPWR VPWR _1131_ sky130_fd_sc_hd__buf_4
XFILLER_0_11_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2451_ net275 _1077_ _1060_ VGND VGND VPWR VPWR _1078_ sky130_fd_sc_hd__mux2_1
X_2382_ net552 _1023_ _1017_ VGND VGND VPWR VPWR _1024_ sky130_fd_sc_hd__mux2_1
X_4121_ clknet_leaf_51_clk _0161_ VGND VGND VPWR VPWR instance_2.data\[1\]\[17\] sky130_fd_sc_hd__dfxtp_1
X_4052_ clknet_leaf_40_clk _0092_ VGND VGND VPWR VPWR instance_1.data\[1\]\[20\] sky130_fd_sc_hd__dfxtp_1
Xinput4 wdata[0] VGND VGND VPWR VPWR net4 sky130_fd_sc_hd__buf_1
X_3003_ _1440_ VGND VGND VPWR VPWR _0266_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_36_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_36_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_47_650 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_86_371 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3905_ _1915_ VGND VGND VPWR VPWR _0693_ sky130_fd_sc_hd__clkbuf_1
X_3836_ _1879_ VGND VGND VPWR VPWR _0660_ sky130_fd_sc_hd__clkbuf_1
X_3767_ _1842_ VGND VGND VPWR VPWR _0628_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_27_482 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_14_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2718_ net188 _1283_ _1264_ VGND VGND VPWR VPWR _1284_ sky130_fd_sc_hd__mux2_1
X_3698_ net150 VGND VGND VPWR VPWR _1806_ sky130_fd_sc_hd__buf_4
XFILLER_0_42_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2649_ net214 _1229_ _1230_ VGND VGND VPWR VPWR _1231_ sky130_fd_sc_hd__mux2_1
X_4319_ clknet_leaf_54_clk _0359_ VGND VGND VPWR VPWR instance_1.data\[3\]\[71\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_2_220 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_69_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_81_973 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_37_202 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_80_514 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_37_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_92_1070 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_20_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_92_1081 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_87_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_44_620 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_16_355 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_28_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_56_511 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_56_522 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_68_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1951_ instance_1.rdata\[2\] instance_2.rdata\[2\] _0722_ VGND VGND VPWR VPWR _0725_
+ sky130_fd_sc_hd__mux2_1
XFILLER_0_28_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_71_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_71_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4670_ clknet_leaf_10_clk _0710_ VGND VGND VPWR VPWR instance_2.data\[3\]\[62\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_3_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3621_ _1765_ VGND VGND VPWR VPWR _0559_ sky130_fd_sc_hd__clkbuf_1
X_3552_ _1729_ VGND VGND VPWR VPWR _0526_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_11_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2503_ net238 _1117_ _1094_ VGND VGND VPWR VPWR _1118_ sky130_fd_sc_hd__mux2_1
XFILLER_0_51_260 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3483_ _1693_ VGND VGND VPWR VPWR _0493_ sky130_fd_sc_hd__clkbuf_1
X_2434_ net706 _1064_ _1060_ VGND VGND VPWR VPWR _1065_ sky130_fd_sc_hd__mux2_1
X_2365_ _1010_ VGND VGND VPWR VPWR _0058_ sky130_fd_sc_hd__clkbuf_1
X_4104_ clknet_leaf_0_clk _0144_ VGND VGND VPWR VPWR instance_2.data\[1\]\[0\] sky130_fd_sc_hd__dfxtp_1
X_2296_ net1 VGND VGND VPWR VPWR _0957_ sky130_fd_sc_hd__buf_4
X_4035_ clknet_leaf_61_clk _0075_ VGND VGND VPWR VPWR instance_1.data\[1\]\[3\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_78_124 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_74_341 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_6_151 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3819_ _1870_ VGND VGND VPWR VPWR _0652_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_50_678 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_42_271 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_6_Left_99 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_69_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_84_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_77_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_38_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_13_325 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_65_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_21_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_21_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_84_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2150_ _0844_ VGND VGND VPWR VPWR _0009_ sky130_fd_sc_hd__clkbuf_1
X_2081_ instance_1.rdata\[64\] instance_2.rdata\[64\] _0788_ VGND VGND VPWR VPWR _0793_
+ sky130_fd_sc_hd__mux2_1
XFILLER_0_88_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_75_116 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_29_500 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_8_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2983_ _0952_ net843 _1428_ VGND VGND VPWR VPWR _1430_ sky130_fd_sc_hd__mux2_1
XFILLER_0_83_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_56_396 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xinput40 wdata[42] VGND VGND VPWR VPWR net40 sky130_fd_sc_hd__buf_1
X_4653_ clknet_leaf_21_clk _0693_ VGND VGND VPWR VPWR instance_2.data\[3\]\[45\] sky130_fd_sc_hd__dfxtp_1
Xinput51 wdata[52] VGND VGND VPWR VPWR net51 sky130_fd_sc_hd__buf_1
X_4584_ clknet_leaf_18_clk _0624_ VGND VGND VPWR VPWR instance_1.data\[0\]\[48\] sky130_fd_sc_hd__dfxtp_1
Xinput73 wdata[7] VGND VGND VPWR VPWR net73 sky130_fd_sc_hd__buf_1
Xinput62 wdata[62] VGND VGND VPWR VPWR net62 sky130_fd_sc_hd__buf_1
X_3604_ _1756_ VGND VGND VPWR VPWR _0551_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_12_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3535_ _1720_ VGND VGND VPWR VPWR _0518_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_24_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3466_ _1684_ VGND VGND VPWR VPWR _0485_ sky130_fd_sc_hd__clkbuf_1
X_2417_ _1050_ VGND VGND VPWR VPWR _0070_ sky130_fd_sc_hd__clkbuf_1
X_3397_ _1648_ VGND VGND VPWR VPWR _0452_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_58_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2348_ _0997_ VGND VGND VPWR VPWR _0054_ sky130_fd_sc_hd__clkbuf_1
X_2279_ _0720_ VGND VGND VPWR VPWR _0944_ sky130_fd_sc_hd__buf_4
XTAP_TAPCELL_ROW_55_726 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4018_ clknet_leaf_11_clk _0058_ VGND VGND VPWR VPWR instance_2.data\[2\]\[58\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_79_444 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_35_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_74_182 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_7_493 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_50_528 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_26_450 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_70_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_38_341 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_38_374 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_79_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_41_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold109 instance_1.rdata\[55\] VGND VGND VPWR VPWR net259 sky130_fd_sc_hd__dlygate4sd3_1
X_3320_ _1607_ VGND VGND VPWR VPWR _0416_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_0_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3251_ _1571_ VGND VGND VPWR VPWR _0383_ sky130_fd_sc_hd__clkbuf_1
X_3182_ net702 _1274_ _1531_ VGND VGND VPWR VPWR _1535_ sky130_fd_sc_hd__mux2_1
X_2202_ net804 _0884_ _0881_ VGND VGND VPWR VPWR _0885_ sky130_fd_sc_hd__mux2_1
X_2133_ instance_2.data\[0\]\[6\] instance_2.data\[1\]\[6\] instance_2.data\[2\]\[6\]
+ instance_2.data\[3\]\[6\] _0821_ _0804_ VGND VGND VPWR VPWR _0831_ sky130_fd_sc_hd__mux4_1
X_2064_ instance_1.rdata\[56\] instance_2.rdata\[56\] _0777_ VGND VGND VPWR VPWR _0784_
+ sky130_fd_sc_hd__mux2_1
XFILLER_0_44_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_76_436 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_91_417 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_44_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_60_773 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2966_ _0925_ net824 _1417_ VGND VGND VPWR VPWR _1421_ sky130_fd_sc_hd__mux2_1
X_2897_ _0807_ net859 _1384_ VGND VGND VPWR VPWR _1385_ sky130_fd_sc_hd__mux2_1
XFILLER_0_44_355 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_8_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_32_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4636_ clknet_leaf_22_clk _0676_ VGND VGND VPWR VPWR instance_2.data\[3\]\[28\] sky130_fd_sc_hd__dfxtp_1
Xhold610 instance_2.rdata\[16\] VGND VGND VPWR VPWR net760 sky130_fd_sc_hd__dlygate4sd3_1
Xhold621 instance_1.data\[1\]\[67\] VGND VGND VPWR VPWR net771 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_8_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xhold643 instance_2.data\[0\]\[15\] VGND VGND VPWR VPWR net793 sky130_fd_sc_hd__dlygate4sd3_1
Xhold632 instance_2.rdata\[5\] VGND VGND VPWR VPWR net782 sky130_fd_sc_hd__dlygate4sd3_1
Xhold654 instance_2.data\[2\]\[21\] VGND VGND VPWR VPWR net804 sky130_fd_sc_hd__dlygate4sd3_1
X_4567_ clknet_leaf_33_clk _0607_ VGND VGND VPWR VPWR instance_1.data\[0\]\[31\] sky130_fd_sc_hd__dfxtp_1
X_4498_ clknet_leaf_31_clk _0538_ VGND VGND VPWR VPWR instance_2.rdata\[34\] sky130_fd_sc_hd__dfxtp_1
Xhold665 instance_2.rdata\[10\] VGND VGND VPWR VPWR net815 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_12_274 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3518_ _1711_ VGND VGND VPWR VPWR _0510_ sky130_fd_sc_hd__clkbuf_1
Xhold676 instance_2.data\[0\]\[11\] VGND VGND VPWR VPWR net826 sky130_fd_sc_hd__dlygate4sd3_1
Xhold687 instance_2.rdata\[22\] VGND VGND VPWR VPWR net837 sky130_fd_sc_hd__dlygate4sd3_1
X_3449_ _1675_ VGND VGND VPWR VPWR _0477_ sky130_fd_sc_hd__clkbuf_1
Xhold698 instance_2.rdata\[33\] VGND VGND VPWR VPWR net848 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_23_420 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_7_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_23_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_35_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_62_152 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_50_336 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_50_369 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_89_1042 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_81_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_81_28 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_58_403 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_74_898 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2820_ _1343_ VGND VGND VPWR VPWR _0180_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_38_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_66_480 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2751_ _1307_ VGND VGND VPWR VPWR _0147_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_38_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2682_ net57 _1255_ _1233_ VGND VGND VPWR VPWR _1256_ sky130_fd_sc_hd__mux2_1
X_4421_ clknet_leaf_37_clk _0461_ VGND VGND VPWR VPWR instance_1.data\[2\]\[29\] sky130_fd_sc_hd__dfxtp_1
X_4352_ clknet_leaf_33_clk _0392_ VGND VGND VPWR VPWR instance_1.rdata\[32\] sky130_fd_sc_hd__dfxtp_1
X_4283_ clknet_leaf_30_clk _0323_ VGND VGND VPWR VPWR instance_1.data\[3\]\[35\] sky130_fd_sc_hd__dfxtp_1
X_3303_ _1598_ VGND VGND VPWR VPWR _0408_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_39_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3234_ _1562_ VGND VGND VPWR VPWR _0375_ sky130_fd_sc_hd__clkbuf_1
X_3165_ net462 _1247_ _1520_ VGND VGND VPWR VPWR _1526_ sky130_fd_sc_hd__mux2_1
X_2116_ instance_2.data\[0\]\[2\] instance_2.data\[1\]\[2\] instance_2.data\[2\]\[2\]
+ instance_2.data\[3\]\[2\] _0802_ _0804_ VGND VGND VPWR VPWR _0818_ sky130_fd_sc_hd__mux4_1
X_3096_ net254 _1135_ _1487_ VGND VGND VPWR VPWR _1490_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_65_821 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2047_ instance_1.rdata\[48\] instance_2.rdata\[48\] _0766_ VGND VGND VPWR VPWR _0775_
+ sky130_fd_sc_hd__mux2_1
X_3998_ clknet_leaf_24_clk _0038_ VGND VGND VPWR VPWR instance_2.data\[2\]\[38\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_36_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2949_ _0897_ net723 _1406_ VGND VGND VPWR VPWR _1412_ sky130_fd_sc_hd__mux2_1
XFILLER_0_32_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_32_358 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4619_ clknet_leaf_49_clk _0659_ VGND VGND VPWR VPWR instance_2.data\[3\]\[11\] sky130_fd_sc_hd__dfxtp_1
Xhold451 instance_1.data\[2\]\[20\] VGND VGND VPWR VPWR net601 sky130_fd_sc_hd__dlygate4sd3_1
Xhold440 instance_1.data\[2\]\[29\] VGND VGND VPWR VPWR net590 sky130_fd_sc_hd__dlygate4sd3_1
Xhold462 instance_2.data\[3\]\[55\] VGND VGND VPWR VPWR net612 sky130_fd_sc_hd__dlygate4sd3_1
Xhold473 instance_1.data\[0\]\[71\] VGND VGND VPWR VPWR net623 sky130_fd_sc_hd__dlygate4sd3_1
Xhold484 instance_1.data\[2\]\[64\] VGND VGND VPWR VPWR net634 sky130_fd_sc_hd__dlygate4sd3_1
Xhold495 instance_1.rdata\[30\] VGND VGND VPWR VPWR net645 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_67_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_0_192 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_67_266 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_27_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_35_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_50_122 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_31_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_79_946 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_92_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_25_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_34_526 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_46_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3921_ net345 _0993_ _1920_ VGND VGND VPWR VPWR _1924_ sky130_fd_sc_hd__mux2_1
XFILLER_0_73_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3852_ net710 _0880_ _1887_ VGND VGND VPWR VPWR _1888_ sky130_fd_sc_hd__mux2_1
X_2803_ _1334_ VGND VGND VPWR VPWR _0172_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_26_152 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3783_ net308 _1263_ _1850_ VGND VGND VPWR VPWR _1851_ sky130_fd_sc_hd__mux2_1
X_2734_ net264 _1295_ _1059_ VGND VGND VPWR VPWR _1296_ sky130_fd_sc_hd__mux2_1
X_2665_ net53 _1242_ _1233_ VGND VGND VPWR VPWR _1243_ sky130_fd_sc_hd__mux2_1
X_2596_ _1189_ VGND VGND VPWR VPWR _0110_ sky130_fd_sc_hd__clkbuf_1
X_4404_ clknet_leaf_46_clk _0444_ VGND VGND VPWR VPWR instance_1.data\[2\]\[12\] sky130_fd_sc_hd__dfxtp_1
X_4335_ clknet_leaf_50_clk _0375_ VGND VGND VPWR VPWR instance_1.rdata\[15\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_1_296 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4266_ clknet_leaf_43_clk _0306_ VGND VGND VPWR VPWR instance_1.data\[3\]\[18\] sky130_fd_sc_hd__dfxtp_1
X_3217_ _1553_ VGND VGND VPWR VPWR _0367_ sky130_fd_sc_hd__clkbuf_1
X_4197_ clknet_leaf_52_clk _0237_ VGND VGND VPWR VPWR instance_2.data\[0\]\[21\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_66_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_66_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3148_ net234 _1219_ _1509_ VGND VGND VPWR VPWR _1517_ sky130_fd_sc_hd__mux2_1
X_3079_ net401 _1107_ _1476_ VGND VGND VPWR VPWR _1481_ sky130_fd_sc_hd__mux2_1
XFILLER_0_92_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_59_Left_152 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_92_545 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_60_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_32_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_68_Left_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold270 instance_1.data\[0\]\[56\] VGND VGND VPWR VPWR net420 sky130_fd_sc_hd__dlygate4sd3_1
Xhold292 instance_1.data\[2\]\[49\] VGND VGND VPWR VPWR net442 sky130_fd_sc_hd__dlygate4sd3_1
Xhold281 instance_2.data\[1\]\[11\] VGND VGND VPWR VPWR net431 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_5_251 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_86_1012 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_77_Left_170 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_84_993 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_83_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_43_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_23_122 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_23_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_87_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2450_ net59 _1076_ _1063_ VGND VGND VPWR VPWR _1077_ sky130_fd_sc_hd__mux2_1
X_2381_ _1022_ net62 _1012_ VGND VGND VPWR VPWR _1023_ sky130_fd_sc_hd__mux2_1
X_4120_ clknet_leaf_47_clk _0160_ VGND VGND VPWR VPWR instance_2.data\[1\]\[16\] sky130_fd_sc_hd__dfxtp_1
X_4051_ clknet_leaf_43_clk _0091_ VGND VGND VPWR VPWR instance_1.data\[1\]\[19\] sky130_fd_sc_hd__dfxtp_1
Xinput5 wdata[10] VGND VGND VPWR VPWR net5 sky130_fd_sc_hd__buf_1
XFILLER_0_36_64 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3002_ _0982_ net698 _1439_ VGND VGND VPWR VPWR _1440_ sky130_fd_sc_hd__mux2_1
XFILLER_0_59_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_59_542 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_74_523 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3904_ net779 _0965_ _1909_ VGND VGND VPWR VPWR _1915_ sky130_fd_sc_hd__mux2_1
XFILLER_0_52_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3835_ net371 _0853_ _1876_ VGND VGND VPWR VPWR _1879_ sky130_fd_sc_hd__mux2_1
X_3766_ net416 _1237_ _1839_ VGND VGND VPWR VPWR _1842_ sky130_fd_sc_hd__mux2_1
XFILLER_0_14_122 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2717_ net66 _1282_ _1267_ VGND VGND VPWR VPWR _1283_ sky130_fd_sc_hd__mux2_1
XFILLER_0_72_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3697_ _1805_ VGND VGND VPWR VPWR _0595_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_42_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2648_ _1059_ VGND VGND VPWR VPWR _1230_ sky130_fd_sc_hd__buf_4
X_2579_ _1176_ VGND VGND VPWR VPWR _0106_ sky130_fd_sc_hd__clkbuf_1
X_4318_ clknet_leaf_53_clk _0358_ VGND VGND VPWR VPWR instance_1.data\[3\]\[70\] sky130_fd_sc_hd__dfxtp_1
X_4249_ clknet_leaf_61_clk _0289_ VGND VGND VPWR VPWR instance_1.data\[3\]\[1\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_2_221 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_65_523 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_37_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_33_431 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_92_1071 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_92_1082 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_87_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_87_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_44_621 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_16_356 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1950_ _0724_ VGND VGND VPWR VPWR net88 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_83_386 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_22_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3620_ _0998_ net838 _1759_ VGND VGND VPWR VPWR _1765_ sky130_fd_sc_hd__mux2_1
X_3551_ _0886_ net837 _1726_ VGND VGND VPWR VPWR _1729_ sky130_fd_sc_hd__mux2_1
X_2502_ net12 _1116_ _1097_ VGND VGND VPWR VPWR _1117_ sky130_fd_sc_hd__mux2_1
XFILLER_0_51_272 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_11_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3482_ net547 _1268_ _1691_ VGND VGND VPWR VPWR _1693_ sky130_fd_sc_hd__mux2_1
XFILLER_0_11_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2433_ net15 _1062_ _1063_ VGND VGND VPWR VPWR _1064_ sky130_fd_sc_hd__mux2_1
X_2364_ net832 _1009_ _0983_ VGND VGND VPWR VPWR _1010_ sky130_fd_sc_hd__mux2_1
X_4103_ clknet_leaf_54_clk _0143_ VGND VGND VPWR VPWR instance_1.data\[1\]\[71\] sky130_fd_sc_hd__dfxtp_1
X_2295_ _0956_ VGND VGND VPWR VPWR _0042_ sky130_fd_sc_hd__clkbuf_1
X_4034_ clknet_leaf_61_clk _0074_ VGND VGND VPWR VPWR instance_1.data\[1\]\[2\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_78_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_2_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_63_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_19_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_47_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_19_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_6_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3818_ net231 _0826_ _1865_ VGND VGND VPWR VPWR _1870_ sky130_fd_sc_hd__mux2_1
XFILLER_0_34_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_50_679 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_15_442 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_6_163 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3749_ net556 _1209_ _1828_ VGND VGND VPWR VPWR _1833_ sky130_fd_sc_hd__mux2_1
XFILLER_0_15_486 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_58_746 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_69_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_84_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_38_523 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_38_545 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_13_326 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_0_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_0_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_21_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_88_401 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2080_ _0792_ VGND VGND VPWR VPWR net136 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_88_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2982_ _1429_ VGND VGND VPWR VPWR _0256_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_90_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_56_342 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_16_239 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4652_ clknet_leaf_21_clk _0692_ VGND VGND VPWR VPWR instance_2.data\[3\]\[44\] sky130_fd_sc_hd__dfxtp_1
X_3603_ _0971_ net865 _1748_ VGND VGND VPWR VPWR _1756_ sky130_fd_sc_hd__mux2_1
Xinput30 wdata[33] VGND VGND VPWR VPWR net30 sky130_fd_sc_hd__clkbuf_1
Xinput41 wdata[43] VGND VGND VPWR VPWR net41 sky130_fd_sc_hd__buf_1
X_4583_ clknet_leaf_19_clk _0623_ VGND VGND VPWR VPWR instance_1.data\[0\]\[47\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_71_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_12_401 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xinput63 wdata[63] VGND VGND VPWR VPWR net63 sky130_fd_sc_hd__buf_1
Xinput52 wdata[53] VGND VGND VPWR VPWR net52 sky130_fd_sc_hd__buf_1
XFILLER_0_12_445 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3534_ _0859_ net496 _1715_ VGND VGND VPWR VPWR _1720_ sky130_fd_sc_hd__mux2_1
Xinput74 wdata[8] VGND VGND VPWR VPWR net74 sky130_fd_sc_hd__buf_1
X_3465_ net404 _1240_ _1680_ VGND VGND VPWR VPWR _1684_ sky130_fd_sc_hd__mux2_1
X_2416_ net482 _1049_ _0812_ VGND VGND VPWR VPWR _1050_ sky130_fd_sc_hd__mux2_1
X_3396_ net601 _1127_ _1647_ VGND VGND VPWR VPWR _1648_ sky130_fd_sc_hd__mux2_1
XFILLER_0_35_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2347_ net540 _0996_ _0983_ VGND VGND VPWR VPWR _0997_ sky130_fd_sc_hd__mux2_1
X_2278_ instance_2.data\[0\]\[39\] instance_2.data\[1\]\[39\] instance_2.data\[2\]\[39\]
+ instance_2.data\[3\]\[39\] _0923_ _0936_ VGND VGND VPWR VPWR _0943_ sky130_fd_sc_hd__mux4_1
XFILLER_0_74_72 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4017_ clknet_leaf_11_clk _0057_ VGND VGND VPWR VPWR instance_2.data\[2\]\[57\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_74_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_74_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_30_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_26_451 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_38_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_41_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_80_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_21_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_21_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_21_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_0_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_13_Left_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3250_ net418 _1137_ _1567_ VGND VGND VPWR VPWR _1571_ sky130_fd_sc_hd__mux2_1
X_3181_ _1534_ VGND VGND VPWR VPWR _0350_ sky130_fd_sc_hd__clkbuf_1
X_2201_ _0883_ net17 _0876_ VGND VGND VPWR VPWR _0884_ sky130_fd_sc_hd__mux2_1
X_2132_ _0830_ VGND VGND VPWR VPWR _0005_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_44_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2063_ _0783_ VGND VGND VPWR VPWR net127 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_88_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_76_459 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_22_Left_115 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_48_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_29_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_63_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_91_429 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_56_161 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2965_ _1420_ VGND VGND VPWR VPWR _0248_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_60_774 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2896_ _1383_ VGND VGND VPWR VPWR _1384_ sky130_fd_sc_hd__buf_4
XFILLER_0_32_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4635_ clknet_leaf_37_clk _0675_ VGND VGND VPWR VPWR instance_2.data\[3\]\[27\] sky130_fd_sc_hd__dfxtp_1
Xhold600 instance_2.rdata\[6\] VGND VGND VPWR VPWR net750 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_8_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_4_464 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xhold611 instance_2.data\[2\]\[15\] VGND VGND VPWR VPWR net761 sky130_fd_sc_hd__dlygate4sd3_1
X_4566_ clknet_leaf_33_clk _0606_ VGND VGND VPWR VPWR instance_1.data\[0\]\[30\] sky130_fd_sc_hd__dfxtp_1
X_3517_ _0831_ net750 _1704_ VGND VGND VPWR VPWR _1711_ sky130_fd_sc_hd__mux2_1
Xhold633 instance_1.data\[1\]\[7\] VGND VGND VPWR VPWR net783 sky130_fd_sc_hd__dlygate4sd3_1
XPHY_EDGE_ROW_31_Left_124 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold622 instance_2.data\[2\]\[22\] VGND VGND VPWR VPWR net772 sky130_fd_sc_hd__dlygate4sd3_1
Xhold644 instance_2.data\[1\]\[55\] VGND VGND VPWR VPWR net794 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_12_286 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold655 instance_2.data\[3\]\[22\] VGND VGND VPWR VPWR net805 sky130_fd_sc_hd__dlygate4sd3_1
Xhold677 instance_2.data\[0\]\[43\] VGND VGND VPWR VPWR net827 sky130_fd_sc_hd__dlygate4sd3_1
Xhold666 instance_2.data\[0\]\[59\] VGND VGND VPWR VPWR net816 sky130_fd_sc_hd__dlygate4sd3_1
Xhold688 instance_2.rdata\[55\] VGND VGND VPWR VPWR net838 sky130_fd_sc_hd__dlygate4sd3_1
X_4497_ clknet_leaf_31_clk _0537_ VGND VGND VPWR VPWR instance_2.rdata\[33\] sky130_fd_sc_hd__dfxtp_1
X_3448_ net703 _1213_ _1669_ VGND VGND VPWR VPWR _1675_ sky130_fd_sc_hd__mux2_1
Xhold699 instance_2.data\[0\]\[29\] VGND VGND VPWR VPWR net849 sky130_fd_sc_hd__dlygate4sd3_1
X_3379_ net151 _1101_ _1636_ VGND VGND VPWR VPWR _1639_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_68_841 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_40_Left_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_67_426 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_23_421 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_23_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_50_348 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_89_1043 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_85_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_85_212 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_74_899 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_58_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_26_312 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2750_ net599 _0823_ _1303_ VGND VGND VPWR VPWR _1307_ sky130_fd_sc_hd__mux2_1
XFILLER_0_26_345 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_66_492 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2681_ instance_1.data\[0\]\[58\] instance_1.data\[1\]\[58\] instance_1.data\[2\]\[58\]
+ instance_1.data\[3\]\[58\] _1245_ _1224_ VGND VGND VPWR VPWR _1255_ sky130_fd_sc_hd__mux4_1
XFILLER_0_14_518 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_41_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4420_ clknet_leaf_35_clk _0460_ VGND VGND VPWR VPWR instance_1.data\[2\]\[28\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_22_551 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4351_ clknet_leaf_33_clk _0391_ VGND VGND VPWR VPWR instance_1.rdata\[31\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_69_9 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4282_ clknet_leaf_31_clk _0322_ VGND VGND VPWR VPWR instance_1.data\[3\]\[34\] sky130_fd_sc_hd__dfxtp_1
X_3302_ net527 _1221_ _1589_ VGND VGND VPWR VPWR _1598_ sky130_fd_sc_hd__mux2_1
X_3233_ net563 _1110_ _1556_ VGND VGND VPWR VPWR _1562_ sky130_fd_sc_hd__mux2_1
X_3164_ _1525_ VGND VGND VPWR VPWR _0342_ sky130_fd_sc_hd__clkbuf_1
X_2115_ _0817_ VGND VGND VPWR VPWR _0001_ sky130_fd_sc_hd__clkbuf_1
X_3095_ _1489_ VGND VGND VPWR VPWR _0309_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_55_74 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_49_404 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2046_ _0774_ VGND VGND VPWR VPWR net118 sky130_fd_sc_hd__buf_1
X_3997_ clknet_leaf_24_clk _0037_ VGND VGND VPWR VPWR instance_2.data\[2\]\[37\] sky130_fd_sc_hd__dfxtp_1
X_2948_ _1411_ VGND VGND VPWR VPWR _0240_ sky130_fd_sc_hd__clkbuf_1
X_4618_ clknet_leaf_50_clk _0658_ VGND VGND VPWR VPWR instance_2.data\[3\]\[10\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_4_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2879_ _1374_ VGND VGND VPWR VPWR _0208_ sky130_fd_sc_hd__clkbuf_1
Xhold463 instance_1.data\[2\]\[59\] VGND VGND VPWR VPWR net613 sky130_fd_sc_hd__dlygate4sd3_1
X_4549_ clknet_leaf_44_clk _0589_ VGND VGND VPWR VPWR instance_1.data\[0\]\[13\] sky130_fd_sc_hd__dfxtp_1
Xhold430 instance_1.data\[2\]\[26\] VGND VGND VPWR VPWR net580 sky130_fd_sc_hd__dlygate4sd3_1
Xhold452 instance_2.data\[0\]\[56\] VGND VGND VPWR VPWR net602 sky130_fd_sc_hd__dlygate4sd3_1
Xhold441 instance_2.data\[1\]\[47\] VGND VGND VPWR VPWR net591 sky130_fd_sc_hd__dlygate4sd3_1
Xhold474 instance_1.data\[3\]\[58\] VGND VGND VPWR VPWR net624 sky130_fd_sc_hd__dlygate4sd3_1
Xhold485 instance_1.data\[0\]\[28\] VGND VGND VPWR VPWR net635 sky130_fd_sc_hd__dlygate4sd3_1
Xhold496 instance_2.data\[3\]\[29\] VGND VGND VPWR VPWR net646 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_0_193 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_27_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_23_326 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_50_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_8_271 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_79_947 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_25_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3920_ _1923_ VGND VGND VPWR VPWR _0700_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_34_527 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3851_ _1864_ VGND VGND VPWR VPWR _1887_ sky130_fd_sc_hd__buf_4
XFILLER_0_58_278 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_504 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_26_120 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3782_ net150 VGND VGND VPWR VPWR _1850_ sky130_fd_sc_hd__buf_4
X_2802_ net271 _0907_ _1325_ VGND VGND VPWR VPWR _1334_ sky130_fd_sc_hd__mux2_1
X_2733_ net71 _1294_ _1267_ VGND VGND VPWR VPWR _1295_ sky130_fd_sc_hd__mux2_1
XFILLER_0_41_76 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_81_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_26_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2664_ instance_1.data\[0\]\[54\] instance_1.data\[1\]\[54\] instance_1.data\[2\]\[54\]
+ instance_1.data\[3\]\[54\] _1211_ _1224_ VGND VGND VPWR VPWR _1242_ sky130_fd_sc_hd__mux4_1
X_2595_ net408 _1188_ _1162_ VGND VGND VPWR VPWR _1189_ sky130_fd_sc_hd__mux2_1
XFILLER_0_10_510 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4403_ clknet_leaf_48_clk _0443_ VGND VGND VPWR VPWR instance_1.data\[2\]\[11\] sky130_fd_sc_hd__dfxtp_1
X_4334_ clknet_leaf_45_clk _0374_ VGND VGND VPWR VPWR instance_1.rdata\[14\] sky130_fd_sc_hd__dfxtp_1
X_4265_ clknet_leaf_43_clk _0305_ VGND VGND VPWR VPWR instance_1.data\[3\]\[17\] sky130_fd_sc_hd__dfxtp_1
X_3216_ net232 _1082_ _1545_ VGND VGND VPWR VPWR _1553_ sky130_fd_sc_hd__mux2_1
X_4196_ clknet_leaf_51_clk _0236_ VGND VGND VPWR VPWR instance_2.data\[0\]\[20\] sky130_fd_sc_hd__dfxtp_1
X_3147_ _1516_ VGND VGND VPWR VPWR _0334_ sky130_fd_sc_hd__clkbuf_1
X_3078_ _1480_ VGND VGND VPWR VPWR _0301_ sky130_fd_sc_hd__clkbuf_1
X_2029_ _0765_ VGND VGND VPWR VPWR net109 sky130_fd_sc_hd__buf_1
XFILLER_0_64_204 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_60_410 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_32_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xhold271 instance_2.data\[3\]\[8\] VGND VGND VPWR VPWR net421 sky130_fd_sc_hd__dlygate4sd3_1
Xhold260 instance_1.data\[0\]\[21\] VGND VGND VPWR VPWR net410 sky130_fd_sc_hd__dlygate4sd3_1
Xhold293 instance_2.data\[1\]\[34\] VGND VGND VPWR VPWR net443 sky130_fd_sc_hd__dlygate4sd3_1
Xhold282 instance_1.rdata\[6\] VGND VGND VPWR VPWR net432 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_76_917 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_86_1013 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_84_994 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_28_418 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_28_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_11_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_51_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_63_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_87_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2380_ instance_2.data\[0\]\[62\] instance_2.data\[1\]\[62\] instance_2.data\[2\]\[62\]
+ instance_2.data\[3\]\[62\] _0991_ _1004_ VGND VGND VPWR VPWR _1022_ sky130_fd_sc_hd__mux4_1
X_4050_ clknet_leaf_44_clk _0090_ VGND VGND VPWR VPWR instance_1.data\[1\]\[18\] sky130_fd_sc_hd__dfxtp_1
Xinput6 wdata[11] VGND VGND VPWR VPWR net6 sky130_fd_sc_hd__buf_1
XFILLER_0_36_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3001_ _1383_ VGND VGND VPWR VPWR _1439_ sky130_fd_sc_hd__buf_4
XTAP_TAPCELL_ROW_19_376 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3903_ _1914_ VGND VGND VPWR VPWR _0692_ sky130_fd_sc_hd__clkbuf_1
X_3834_ _1878_ VGND VGND VPWR VPWR _0659_ sky130_fd_sc_hd__clkbuf_1
X_3765_ _1841_ VGND VGND VPWR VPWR _0627_ sky130_fd_sc_hd__clkbuf_1
X_3696_ net549 _1124_ _1795_ VGND VGND VPWR VPWR _1805_ sky130_fd_sc_hd__mux2_1
X_2716_ instance_1.data\[0\]\[66\] instance_1.data\[1\]\[66\] instance_1.data\[2\]\[66\]
+ instance_1.data\[3\]\[66\] _0802_ _1258_ VGND VGND VPWR VPWR _1282_ sky130_fd_sc_hd__mux4_1
X_2647_ net49 _1228_ _1199_ VGND VGND VPWR VPWR _1229_ sky130_fd_sc_hd__mux2_1
XFILLER_0_14_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_2_551 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_65_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2578_ net445 _1175_ _1162_ VGND VGND VPWR VPWR _1176_ sky130_fd_sc_hd__mux2_1
XFILLER_0_10_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4317_ clknet_leaf_5_clk _0357_ VGND VGND VPWR VPWR instance_1.data\[3\]\[69\] sky130_fd_sc_hd__dfxtp_1
X_4248_ clknet_leaf_60_clk _0288_ VGND VGND VPWR VPWR instance_1.data\[3\]\[0\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_2_222 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4179_ clknet_leaf_59_clk _0219_ VGND VGND VPWR VPWR instance_2.data\[0\]\[3\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_53_699 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_14_Right_14 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_9_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xclkbuf_3_3__f_clk clknet_0_clk VGND VGND VPWR VPWR clknet_3_3__leaf_clk sky130_fd_sc_hd__clkbuf_16
XFILLER_0_92_398 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_45_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_60_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_92_1083 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_92_1072 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_23_Right_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_87_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_87_148 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_44_622 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_32_Right_32 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_83_376 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_43_207 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_24_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_24_432 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3550_ _1728_ VGND VGND VPWR VPWR _0525_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_3_348 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_24_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2501_ instance_1.data\[0\]\[17\] instance_1.data\[1\]\[17\] instance_1.data\[2\]\[17\]
+ instance_1.data\[3\]\[17\] _1109_ _1088_ VGND VGND VPWR VPWR _1116_ sky130_fd_sc_hd__mux4_1
X_3481_ _1692_ VGND VGND VPWR VPWR _0492_ sky130_fd_sc_hd__clkbuf_1
X_2432_ _1045_ VGND VGND VPWR VPWR _1063_ sky130_fd_sc_hd__buf_4
XPHY_EDGE_ROW_41_Right_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2363_ _1008_ net57 _0978_ VGND VGND VPWR VPWR _1009_ sky130_fd_sc_hd__mux2_1
X_4102_ clknet_leaf_6_clk _0142_ VGND VGND VPWR VPWR instance_1.data\[1\]\[70\] sky130_fd_sc_hd__dfxtp_1
X_4033_ clknet_leaf_61_clk _0073_ VGND VGND VPWR VPWR instance_1.data\[1\]\[1\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_47_86 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2294_ net479 _0955_ _0949_ VGND VGND VPWR VPWR _0956_ sky130_fd_sc_hd__mux2_1
XPHY_EDGE_ROW_50_Right_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_86_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_74_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_62_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3817_ _1869_ VGND VGND VPWR VPWR _0651_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_27_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_62_549 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3748_ _1832_ VGND VGND VPWR VPWR _0619_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_6_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_6_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3679_ _1796_ VGND VGND VPWR VPWR _0586_ sky130_fd_sc_hd__clkbuf_1
Xoutput140 net140 VGND VGND VPWR VPWR rdata[67] sky130_fd_sc_hd__clkbuf_4
XFILLER_0_10_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_58_747 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_69_148 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_84_118 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_13_327 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_leaf_50_clk clknet_3_4__leaf_clk VGND VGND VPWR VPWR clknet_leaf_50_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_0_53_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_92_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_33_240 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_88_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_29_471 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_8_418 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_33_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2981_ _0948_ net695 _1428_ VGND VGND VPWR VPWR _1429_ sky130_fd_sc_hd__mux2_1
Xclkbuf_leaf_41_clk clknet_3_5__leaf_clk VGND VGND VPWR VPWR clknet_leaf_41_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_0_56_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4651_ clknet_leaf_22_clk _0691_ VGND VGND VPWR VPWR instance_2.data\[3\]\[43\] sky130_fd_sc_hd__dfxtp_1
Xinput31 wdata[34] VGND VGND VPWR VPWR net31 sky130_fd_sc_hd__clkbuf_1
X_3602_ _1755_ VGND VGND VPWR VPWR _0550_ sky130_fd_sc_hd__clkbuf_1
Xinput20 wdata[24] VGND VGND VPWR VPWR net20 sky130_fd_sc_hd__buf_1
Xinput42 wdata[44] VGND VGND VPWR VPWR net42 sky130_fd_sc_hd__buf_1
X_4582_ clknet_leaf_18_clk _0622_ VGND VGND VPWR VPWR instance_1.data\[0\]\[46\] sky130_fd_sc_hd__dfxtp_1
Xinput53 wdata[54] VGND VGND VPWR VPWR net53 sky130_fd_sc_hd__buf_1
XFILLER_0_12_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xinput64 wdata[64] VGND VGND VPWR VPWR net64 sky130_fd_sc_hd__buf_1
X_3533_ _1719_ VGND VGND VPWR VPWR _0517_ sky130_fd_sc_hd__clkbuf_1
Xinput75 wdata[9] VGND VGND VPWR VPWR net75 sky130_fd_sc_hd__buf_1
X_3464_ _1683_ VGND VGND VPWR VPWR _0484_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_12_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2415_ _1048_ net71 _1045_ VGND VGND VPWR VPWR _1049_ sky130_fd_sc_hd__mux2_1
X_3395_ _1624_ VGND VGND VPWR VPWR _1647_ sky130_fd_sc_hd__buf_4
X_2346_ _0995_ net53 _0978_ VGND VGND VPWR VPWR _0996_ sky130_fd_sc_hd__mux2_1
X_2277_ _0942_ VGND VGND VPWR VPWR _0038_ sky130_fd_sc_hd__clkbuf_1
X_4016_ clknet_leaf_11_clk _0056_ VGND VGND VPWR VPWR instance_2.data\[2\]\[56\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_66_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_90_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_35_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_63_794 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_leaf_32_clk clknet_3_7__leaf_clk VGND VGND VPWR VPWR clknet_leaf_32_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_0_47_387 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_30_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkbuf_leaf_23_clk clknet_3_6__leaf_clk VGND VGND VPWR VPWR clknet_leaf_23_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_0_53_346 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_21_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2200_ instance_2.data\[0\]\[21\] instance_2.data\[1\]\[21\] instance_2.data\[2\]\[21\]
+ instance_2.data\[3\]\[21\] _0855_ _0868_ VGND VGND VPWR VPWR _0883_ sky130_fd_sc_hd__mux4_1
X_3180_ net724 _1271_ _1531_ VGND VGND VPWR VPWR _1534_ sky130_fd_sc_hd__mux2_1
X_2131_ net551 _0829_ _0813_ VGND VGND VPWR VPWR _0830_ sky130_fd_sc_hd__mux2_1
X_2062_ instance_1.rdata\[55\] instance_2.rdata\[55\] _0777_ VGND VGND VPWR VPWR _0783_
+ sky130_fd_sc_hd__mux2_1
XFILLER_0_88_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_76_416 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_76_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_17_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2964_ _0921_ net764 _1417_ VGND VGND VPWR VPWR _1420_ sky130_fd_sc_hd__mux2_1
Xclkbuf_leaf_14_clk clknet_3_2__leaf_clk VGND VGND VPWR VPWR clknet_leaf_14_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_0_44_313 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_56_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_17_549 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_32_499 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2895_ _1382_ VGND VGND VPWR VPWR _1383_ sky130_fd_sc_hd__buf_4
XFILLER_0_4_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4634_ clknet_leaf_38_clk _0674_ VGND VGND VPWR VPWR instance_2.data\[3\]\[26\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_12_210 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold601 instance_2.rdata\[7\] VGND VGND VPWR VPWR net751 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_8_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4565_ clknet_leaf_34_clk _0605_ VGND VGND VPWR VPWR instance_1.data\[0\]\[29\] sky130_fd_sc_hd__dfxtp_1
Xhold612 instance_2.data\[2\]\[31\] VGND VGND VPWR VPWR net762 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_12_232 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3516_ _1710_ VGND VGND VPWR VPWR _0509_ sky130_fd_sc_hd__clkbuf_1
Xhold645 instance_2.data\[2\]\[65\] VGND VGND VPWR VPWR net795 sky130_fd_sc_hd__dlygate4sd3_1
Xhold634 instance_2.rdata\[30\] VGND VGND VPWR VPWR net784 sky130_fd_sc_hd__dlygate4sd3_1
Xhold623 instance_2.data\[2\]\[57\] VGND VGND VPWR VPWR net773 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_69_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold667 instance_2.rdata\[44\] VGND VGND VPWR VPWR net817 sky130_fd_sc_hd__dlygate4sd3_1
XPHY_EDGE_ROW_4_Right_4 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4496_ clknet_leaf_33_clk _0536_ VGND VGND VPWR VPWR instance_2.rdata\[32\] sky130_fd_sc_hd__dfxtp_1
Xhold678 instance_2.data\[0\]\[58\] VGND VGND VPWR VPWR net828 sky130_fd_sc_hd__dlygate4sd3_1
Xhold656 instance_2.rdata\[57\] VGND VGND VPWR VPWR net806 sky130_fd_sc_hd__dlygate4sd3_1
X_3447_ _1674_ VGND VGND VPWR VPWR _0476_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_12_298 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xhold689 instance_2.rdata\[56\] VGND VGND VPWR VPWR net839 sky130_fd_sc_hd__dlygate4sd3_1
X_3378_ _1638_ VGND VGND VPWR VPWR _0443_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_85_72 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2329_ _0812_ VGND VGND VPWR VPWR _0983_ sky130_fd_sc_hd__buf_4
XTAP_TAPCELL_ROW_68_842 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_67_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_82_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_23_422 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_35_313 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_89_1044 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_81_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_73_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_26_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2680_ _1254_ VGND VGND VPWR VPWR _0129_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_26_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_81_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4350_ clknet_leaf_32_clk _0390_ VGND VGND VPWR VPWR instance_1.rdata\[30\] sky130_fd_sc_hd__dfxtp_1
X_3301_ _1597_ VGND VGND VPWR VPWR _0407_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_1_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4281_ clknet_leaf_31_clk _0321_ VGND VGND VPWR VPWR instance_1.data\[3\]\[33\] sky130_fd_sc_hd__dfxtp_1
X_3232_ _1561_ VGND VGND VPWR VPWR _0374_ sky130_fd_sc_hd__clkbuf_1
Xclkbuf_leaf_3_clk clknet_3_0__leaf_clk VGND VGND VPWR VPWR clknet_leaf_3_clk sky130_fd_sc_hd__clkbuf_8
X_3163_ net852 _1243_ _1520_ VGND VGND VPWR VPWR _1525_ sky130_fd_sc_hd__mux2_1
X_2114_ net155 _0816_ _0813_ VGND VGND VPWR VPWR _0817_ sky130_fd_sc_hd__mux2_1
XFILLER_0_89_541 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3094_ net170 _1132_ _1487_ VGND VGND VPWR VPWR _1489_ sky130_fd_sc_hd__mux2_1
XFILLER_0_55_86 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2045_ instance_1.rdata\[47\] instance_2.rdata\[47\] _0766_ VGND VGND VPWR VPWR _0774_
+ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_37_547 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_9_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_91_205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3996_ clknet_leaf_29_clk _0036_ VGND VGND VPWR VPWR instance_2.data\[2\]\[36\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_29_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_72_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_72_430 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2947_ _0894_ net788 _1406_ VGND VGND VPWR VPWR _1411_ sky130_fd_sc_hd__mux2_1
XFILLER_0_57_493 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_72_463 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_72_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4617_ clknet_leaf_54_clk _0657_ VGND VGND VPWR VPWR instance_2.data\[3\]\[9\] sky130_fd_sc_hd__dfxtp_1
X_2878_ net856 _1030_ _1369_ VGND VGND VPWR VPWR _1374_ sky130_fd_sc_hd__mux2_1
Xhold420 instance_1.data\[3\]\[42\] VGND VGND VPWR VPWR net570 sky130_fd_sc_hd__dlygate4sd3_1
Xhold453 instance_2.data\[0\]\[6\] VGND VGND VPWR VPWR net603 sky130_fd_sc_hd__dlygate4sd3_1
Xhold431 instance_1.data\[3\]\[3\] VGND VGND VPWR VPWR net581 sky130_fd_sc_hd__dlygate4sd3_1
X_4548_ clknet_leaf_45_clk _0588_ VGND VGND VPWR VPWR instance_1.data\[0\]\[12\] sky130_fd_sc_hd__dfxtp_1
Xhold442 instance_1.data\[3\]\[20\] VGND VGND VPWR VPWR net592 sky130_fd_sc_hd__dlygate4sd3_1
Xhold464 instance_1.rdata\[34\] VGND VGND VPWR VPWR net614 sky130_fd_sc_hd__dlygate4sd3_1
X_4479_ clknet_leaf_50_clk _0519_ VGND VGND VPWR VPWR instance_2.rdata\[15\] sky130_fd_sc_hd__dfxtp_1
Xhold475 instance_1.data\[0\]\[69\] VGND VGND VPWR VPWR net625 sky130_fd_sc_hd__dlygate4sd3_1
Xhold486 instance_2.data\[0\]\[23\] VGND VGND VPWR VPWR net636 sky130_fd_sc_hd__dlygate4sd3_1
Xhold497 instance_2.rdata\[63\] VGND VGND VPWR VPWR net647 sky130_fd_sc_hd__dlygate4sd3_1
XPHY_EDGE_ROW_79_Right_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_0_194 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_67_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_88_Right_88 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_8_272 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_79_948 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_92_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_86_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_58_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3850_ _1886_ VGND VGND VPWR VPWR _0667_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_58_268 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3781_ _1849_ VGND VGND VPWR VPWR _0635_ sky130_fd_sc_hd__clkbuf_1
X_2801_ _1333_ VGND VGND VPWR VPWR _0171_ sky130_fd_sc_hd__clkbuf_1
X_2732_ instance_1.data\[0\]\[70\] instance_1.data\[1\]\[70\] instance_1.data\[2\]\[70\]
+ instance_1.data\[3\]\[70\] _0802_ _0804_ VGND VGND VPWR VPWR _1294_ sky130_fd_sc_hd__mux4_1
XTAP_TAPCELL_ROW_42_594 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_81_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_81_271 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2663_ _1241_ VGND VGND VPWR VPWR _0125_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_14_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_41_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2594_ net35 _1187_ _1165_ VGND VGND VPWR VPWR _1188_ sky130_fd_sc_hd__mux2_1
X_4402_ clknet_leaf_49_clk _0442_ VGND VGND VPWR VPWR instance_1.data\[2\]\[10\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_41_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_10_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_522 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4333_ clknet_leaf_46_clk _0373_ VGND VGND VPWR VPWR instance_1.rdata\[13\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_1_254 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4264_ clknet_leaf_43_clk _0304_ VGND VGND VPWR VPWR instance_1.data\[3\]\[16\] sky130_fd_sc_hd__dfxtp_1
X_3215_ _1552_ VGND VGND VPWR VPWR _0366_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_5_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4195_ clknet_leaf_52_clk _0235_ VGND VGND VPWR VPWR instance_2.data\[0\]\[19\] sky130_fd_sc_hd__dfxtp_1
X_3146_ net476 _1216_ _1509_ VGND VGND VPWR VPWR _1516_ sky130_fd_sc_hd__mux2_1
X_3077_ net673 _1104_ _1476_ VGND VGND VPWR VPWR _1480_ sky130_fd_sc_hd__mux2_1
XFILLER_0_89_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_82_62 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_10_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2028_ instance_1.rdata\[39\] instance_2.rdata\[39\] _0755_ VGND VGND VPWR VPWR _0765_
+ sky130_fd_sc_hd__mux2_1
XFILLER_0_49_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_17_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_64_238 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_64_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3979_ clknet_leaf_52_clk _0019_ VGND VGND VPWR VPWR instance_2.data\[2\]\[19\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_32_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_60_444 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_60_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_60_488 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xhold261 instance_1.data\[1\]\[37\] VGND VGND VPWR VPWR net411 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_13_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_40_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold250 instance_2.data\[3\]\[26\] VGND VGND VPWR VPWR net400 sky130_fd_sc_hd__dlygate4sd3_1
Xhold294 instance_1.data\[1\]\[44\] VGND VGND VPWR VPWR net444 sky130_fd_sc_hd__dlygate4sd3_1
Xhold272 instance_1.data\[2\]\[16\] VGND VGND VPWR VPWR net422 sky130_fd_sc_hd__dlygate4sd3_1
Xhold283 instance_2.data\[2\]\[25\] VGND VGND VPWR VPWR net433 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_76_918 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_86_1014 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_84_995 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_11_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_51_466 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_51_499 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xinput7 wdata[12] VGND VGND VPWR VPWR net7 sky130_fd_sc_hd__buf_1
X_3000_ _1438_ VGND VGND VPWR VPWR _0265_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_47_642 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_19_377 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_86_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3902_ net530 _0962_ _1909_ VGND VGND VPWR VPWR _1914_ sky130_fd_sc_hd__mux2_1
X_3833_ net217 _0850_ _1876_ VGND VGND VPWR VPWR _1878_ sky130_fd_sc_hd__mux2_1
XFILLER_0_39_290 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3764_ net167 _1234_ _1839_ VGND VGND VPWR VPWR _1841_ sky130_fd_sc_hd__mux2_1
X_3695_ _1804_ VGND VGND VPWR VPWR _0594_ sky130_fd_sc_hd__clkbuf_1
X_2715_ _1281_ VGND VGND VPWR VPWR _0137_ sky130_fd_sc_hd__clkbuf_1
X_2646_ instance_1.data\[0\]\[50\] instance_1.data\[1\]\[50\] instance_1.data\[2\]\[50\]
+ instance_1.data\[3\]\[50\] _1211_ _1224_ VGND VGND VPWR VPWR _1228_ sky130_fd_sc_hd__mux4_1
XFILLER_0_2_530 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_42_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2577_ net31 _1174_ _1165_ VGND VGND VPWR VPWR _1175_ sky130_fd_sc_hd__mux2_1
XFILLER_0_10_330 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4316_ clknet_leaf_4_clk _0356_ VGND VGND VPWR VPWR instance_1.data\[3\]\[68\] sky130_fd_sc_hd__dfxtp_1
X_4247_ clknet_leaf_53_clk _0287_ VGND VGND VPWR VPWR instance_2.data\[0\]\[71\] sky130_fd_sc_hd__dfxtp_1
X_4178_ clknet_leaf_60_clk _0218_ VGND VGND VPWR VPWR instance_2.data\[0\]\[2\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_2_223 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3129_ net365 _1188_ _1498_ VGND VGND VPWR VPWR _1507_ sky130_fd_sc_hd__mux2_1
XFILLER_0_92_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_81_965 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_77_374 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_37_249 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_92_377 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_60_230 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_92_1084 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_92_1073 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_87_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_16_347 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2500_ _1115_ VGND VGND VPWR VPWR _0088_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_24_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3480_ net709 _1263_ _1691_ VGND VGND VPWR VPWR _1692_ sky130_fd_sc_hd__mux2_1
X_2431_ instance_1.data\[0\]\[1\] instance_1.data\[1\]\[1\] instance_1.data\[2\]\[1\]
+ instance_1.data\[3\]\[1\] _0808_ _1054_ VGND VGND VPWR VPWR _1062_ sky130_fd_sc_hd__mux4_1
X_2362_ instance_2.data\[0\]\[58\] instance_2.data\[1\]\[58\] instance_2.data\[2\]\[58\]
+ instance_2.data\[3\]\[58\] _0991_ _1004_ VGND VGND VPWR VPWR _1008_ sky130_fd_sc_hd__mux4_1
X_4101_ clknet_leaf_5_clk _0141_ VGND VGND VPWR VPWR instance_1.data\[1\]\[69\] sky130_fd_sc_hd__dfxtp_1
X_2293_ _0954_ net40 _0944_ VGND VGND VPWR VPWR _0955_ sky130_fd_sc_hd__mux2_1
X_4032_ clknet_leaf_59_clk _0072_ VGND VGND VPWR VPWR instance_1.data\[1\]\[0\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_63_31 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_59_396 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3816_ net426 _0823_ _1865_ VGND VGND VPWR VPWR _1869_ sky130_fd_sc_hd__mux2_1
XFILLER_0_27_271 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3747_ net385 _1206_ _1828_ VGND VGND VPWR VPWR _1832_ sky130_fd_sc_hd__mux2_1
XFILLER_0_27_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_70_550 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3678_ net620 _1093_ _1795_ VGND VGND VPWR VPWR _1796_ sky130_fd_sc_hd__mux2_1
XFILLER_0_88_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2629_ instance_1.data\[0\]\[46\] instance_1.data\[1\]\[46\] instance_1.data\[2\]\[46\]
+ instance_1.data\[3\]\[46\] _1211_ _1190_ VGND VGND VPWR VPWR _1215_ sky130_fd_sc_hd__mux4_1
Xoutput130 net130 VGND VGND VPWR VPWR rdata[58] sky130_fd_sc_hd__clkbuf_4
XFILLER_0_30_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xoutput141 net141 VGND VGND VPWR VPWR rdata[68] sky130_fd_sc_hd__clkbuf_4
XTAP_TAPCELL_ROW_58_748 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_92_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_92_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_17_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_29_472 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2980_ _1383_ VGND VGND VPWR VPWR _1428_ sky130_fd_sc_hd__buf_4
XFILLER_0_16_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4650_ clknet_leaf_23_clk _0690_ VGND VGND VPWR VPWR instance_2.data\[3\]\[42\] sky130_fd_sc_hd__dfxtp_1
Xinput10 wdata[15] VGND VGND VPWR VPWR net10 sky130_fd_sc_hd__buf_1
Xinput21 wdata[25] VGND VGND VPWR VPWR net21 sky130_fd_sc_hd__buf_1
X_3601_ _0967_ net733 _1748_ VGND VGND VPWR VPWR _1755_ sky130_fd_sc_hd__mux2_1
Xinput43 wdata[45] VGND VGND VPWR VPWR net43 sky130_fd_sc_hd__buf_1
X_4581_ clknet_leaf_19_clk _0621_ VGND VGND VPWR VPWR instance_1.data\[0\]\[45\] sky130_fd_sc_hd__dfxtp_1
Xinput54 wdata[55] VGND VGND VPWR VPWR net54 sky130_fd_sc_hd__buf_1
Xinput32 wdata[35] VGND VGND VPWR VPWR net32 sky130_fd_sc_hd__buf_1
XFILLER_0_3_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3532_ _0856_ net533 _1715_ VGND VGND VPWR VPWR _1719_ sky130_fd_sc_hd__mux2_1
Xinput65 wdata[65] VGND VGND VPWR VPWR net65 sky130_fd_sc_hd__buf_1
Xinput76 wr VGND VGND VPWR VPWR net76 sky130_fd_sc_hd__dlymetal6s2s_1
X_3463_ net235 _1237_ _1680_ VGND VGND VPWR VPWR _1683_ sky130_fd_sc_hd__mux2_1
X_2414_ instance_2.data\[0\]\[70\] instance_2.data\[1\]\[70\] instance_2.data\[2\]\[70\]
+ instance_2.data\[3\]\[70\] _1025_ _0809_ VGND VGND VPWR VPWR _1048_ sky130_fd_sc_hd__mux4_1
X_3394_ _1646_ VGND VGND VPWR VPWR _0451_ sky130_fd_sc_hd__clkbuf_1
X_2345_ instance_2.data\[0\]\[54\] instance_2.data\[1\]\[54\] instance_2.data\[2\]\[54\]
+ instance_2.data\[3\]\[54\] _0991_ _0970_ VGND VGND VPWR VPWR _0995_ sky130_fd_sc_hd__mux4_1
X_2276_ net153 _0941_ _0915_ VGND VGND VPWR VPWR _0942_ sky130_fd_sc_hd__mux2_1
X_4015_ clknet_leaf_11_clk _0055_ VGND VGND VPWR VPWR instance_2.data\[2\]\[55\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_79_436 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_55_718 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_74_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_63_795 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_35_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_62_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_62_369 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_85_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_26_442 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_80_166 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_0_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2130_ _0828_ net59 _0806_ VGND VGND VPWR VPWR _0829_ sky130_fd_sc_hd__mux2_1
X_2061_ _0782_ VGND VGND VPWR VPWR net126 sky130_fd_sc_hd__buf_1
XFILLER_0_48_108 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_44_99 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_60_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2963_ _1419_ VGND VGND VPWR VPWR _0247_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_17_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_56_152 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_60_765 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2894_ _1025_ _0809_ _0810_ VGND VGND VPWR VPWR _1382_ sky130_fd_sc_hd__or3b_1
XFILLER_0_71_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_4_433 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4633_ clknet_leaf_53_clk _0673_ VGND VGND VPWR VPWR instance_2.data\[3\]\[25\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_40_520 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold602 instance_2.data\[1\]\[63\] VGND VGND VPWR VPWR net752 sky130_fd_sc_hd__dlygate4sd3_1
X_4564_ clknet_leaf_35_clk _0604_ VGND VGND VPWR VPWR instance_1.data\[0\]\[28\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_12_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold624 instance_1.data\[2\]\[2\] VGND VGND VPWR VPWR net774 sky130_fd_sc_hd__dlygate4sd3_1
Xhold613 instance_2.data\[3\]\[18\] VGND VGND VPWR VPWR net763 sky130_fd_sc_hd__dlygate4sd3_1
X_3515_ _0828_ net782 _1704_ VGND VGND VPWR VPWR _1710_ sky130_fd_sc_hd__mux2_1
Xhold635 instance_2.data\[0\]\[42\] VGND VGND VPWR VPWR net785 sky130_fd_sc_hd__dlygate4sd3_1
Xhold657 instance_2.rdata\[24\] VGND VGND VPWR VPWR net807 sky130_fd_sc_hd__dlygate4sd3_1
Xhold668 instance_2.rdata\[27\] VGND VGND VPWR VPWR net818 sky130_fd_sc_hd__dlygate4sd3_1
X_4495_ clknet_leaf_33_clk _0535_ VGND VGND VPWR VPWR instance_2.rdata\[31\] sky130_fd_sc_hd__dfxtp_1
Xhold646 instance_2.rdata\[42\] VGND VGND VPWR VPWR net796 sky130_fd_sc_hd__dlygate4sd3_1
Xhold679 instance_2.rdata\[45\] VGND VGND VPWR VPWR net829 sky130_fd_sc_hd__dlygate4sd3_1
X_3446_ net392 _1209_ _1669_ VGND VGND VPWR VPWR _1674_ sky130_fd_sc_hd__mux2_1
X_3377_ net812 _1098_ _1636_ VGND VGND VPWR VPWR _1638_ sky130_fd_sc_hd__mux2_1
XFILLER_0_40_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2328_ _0981_ net49 _0978_ VGND VGND VPWR VPWR _0982_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_68_843 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_79_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2259_ net276 _0928_ _0915_ VGND VGND VPWR VPWR _0929_ sky130_fd_sc_hd__mux2_1
XFILLER_0_47_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_90_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_89_1045 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_38_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_81_442 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_38_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_53_155 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3300_ net382 _1218_ _1589_ VGND VGND VPWR VPWR _1597_ sky130_fd_sc_hd__mux2_1
X_4280_ clknet_leaf_34_clk _0320_ VGND VGND VPWR VPWR instance_1.data\[3\]\[32\] sky130_fd_sc_hd__dfxtp_1
X_3231_ net441 _1106_ _1556_ VGND VGND VPWR VPWR _1561_ sky130_fd_sc_hd__mux2_1
XFILLER_0_39_88 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3162_ _1524_ VGND VGND VPWR VPWR _0341_ sky130_fd_sc_hd__clkbuf_1
X_2113_ _0815_ net15 _0806_ VGND VGND VPWR VPWR _0816_ sky130_fd_sc_hd__mux2_1
X_3093_ _1488_ VGND VGND VPWR VPWR _0308_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_55_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_65_813 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2044_ _0773_ VGND VGND VPWR VPWR net117 sky130_fd_sc_hd__buf_1
XTAP_TAPCELL_ROW_37_548 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_71_31 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_76_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_73_890 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_9_525 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_91_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_71_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3995_ clknet_leaf_36_clk _0035_ VGND VGND VPWR VPWR instance_2.data\[2\]\[35\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_84_280 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2946_ _1410_ VGND VGND VPWR VPWR _0239_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_72_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2877_ _1373_ VGND VGND VPWR VPWR _0207_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_88_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4616_ clknet_leaf_56_clk _0656_ VGND VGND VPWR VPWR instance_2.data\[3\]\[8\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_4_263 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold410 instance_2.data\[2\]\[60\] VGND VGND VPWR VPWR net560 sky130_fd_sc_hd__dlygate4sd3_1
Xhold421 instance_1.data\[2\]\[54\] VGND VGND VPWR VPWR net571 sky130_fd_sc_hd__dlygate4sd3_1
Xhold432 instance_1.data\[2\]\[9\] VGND VGND VPWR VPWR net582 sky130_fd_sc_hd__dlygate4sd3_1
X_4547_ clknet_leaf_48_clk _0587_ VGND VGND VPWR VPWR instance_1.data\[0\]\[11\] sky130_fd_sc_hd__dfxtp_1
Xhold454 instance_2.data\[2\]\[68\] VGND VGND VPWR VPWR net604 sky130_fd_sc_hd__dlygate4sd3_1
Xhold443 instance_2.data\[2\]\[48\] VGND VGND VPWR VPWR net593 sky130_fd_sc_hd__dlygate4sd3_1
Xhold476 instance_1.data\[1\]\[53\] VGND VGND VPWR VPWR net626 sky130_fd_sc_hd__dlygate4sd3_1
X_4478_ clknet_leaf_46_clk _0518_ VGND VGND VPWR VPWR instance_2.rdata\[14\] sky130_fd_sc_hd__dfxtp_1
Xhold487 instance_2.data\[1\]\[19\] VGND VGND VPWR VPWR net637 sky130_fd_sc_hd__dlygate4sd3_1
Xhold465 instance_1.data\[1\]\[32\] VGND VGND VPWR VPWR net615 sky130_fd_sc_hd__dlygate4sd3_1
X_3429_ net319 _1182_ _1658_ VGND VGND VPWR VPWR _1665_ sky130_fd_sc_hd__mux2_1
XFILLER_0_0_480 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold498 instance_1.data\[2\]\[65\] VGND VGND VPWR VPWR net648 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_67_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_0_195 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_82_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_90_261 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_79_949 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_8_273 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_25_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_86_545 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_34_518 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_46_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3780_ net427 _1260_ _1839_ VGND VGND VPWR VPWR _1849_ sky130_fd_sc_hd__mux2_1
XFILLER_0_41_34 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2800_ net619 _0904_ _1325_ VGND VGND VPWR VPWR _1333_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_70_860 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_26_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2731_ _1293_ VGND VGND VPWR VPWR _0141_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_42_595 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2662_ net626 _1240_ _1230_ VGND VGND VPWR VPWR _1241_ sky130_fd_sc_hd__mux2_1
X_4401_ clknet_leaf_57_clk _0441_ VGND VGND VPWR VPWR instance_1.data\[2\]\[9\] sky130_fd_sc_hd__dfxtp_1
X_2593_ instance_1.data\[0\]\[38\] instance_1.data\[1\]\[38\] instance_1.data\[2\]\[38\]
+ instance_1.data\[3\]\[38\] _1177_ _1156_ VGND VGND VPWR VPWR _1187_ sky130_fd_sc_hd__mux4_1
XFILLER_0_41_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_10_545 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4332_ clknet_leaf_48_clk _0372_ VGND VGND VPWR VPWR instance_1.rdata\[12\] sky130_fd_sc_hd__dfxtp_1
X_4263_ clknet_leaf_47_clk _0303_ VGND VGND VPWR VPWR instance_1.data\[3\]\[15\] sky130_fd_sc_hd__dfxtp_1
X_3214_ net432 _1079_ _1545_ VGND VGND VPWR VPWR _1552_ sky130_fd_sc_hd__mux2_1
X_4194_ clknet_leaf_51_clk _0234_ VGND VGND VPWR VPWR instance_2.data\[0\]\[18\] sky130_fd_sc_hd__dfxtp_1
X_3145_ _1515_ VGND VGND VPWR VPWR _0333_ sky130_fd_sc_hd__clkbuf_1
XPHY_EDGE_ROW_19_Left_112 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3076_ _1479_ VGND VGND VPWR VPWR _0300_ sky130_fd_sc_hd__clkbuf_1
X_2027_ _0764_ VGND VGND VPWR VPWR net108 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_17_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_17_100 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3978_ clknet_leaf_50_clk _0018_ VGND VGND VPWR VPWR instance_2.data\[2\]\[18\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_17_133 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2929_ _1401_ VGND VGND VPWR VPWR _0231_ sky130_fd_sc_hd__clkbuf_1
XPHY_EDGE_ROW_28_Left_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_45_442 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_72_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_32_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_60_467 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xhold262 instance_1.data\[1\]\[35\] VGND VGND VPWR VPWR net412 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_13_383 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xhold251 instance_1.data\[3\]\[14\] VGND VGND VPWR VPWR net401 sky130_fd_sc_hd__dlygate4sd3_1
Xhold240 instance_2.data\[0\]\[39\] VGND VGND VPWR VPWR net390 sky130_fd_sc_hd__dlygate4sd3_1
Xhold284 instance_1.data\[0\]\[50\] VGND VGND VPWR VPWR net434 sky130_fd_sc_hd__dlygate4sd3_1
Xhold295 instance_1.data\[1\]\[34\] VGND VGND VPWR VPWR net445 sky130_fd_sc_hd__dlygate4sd3_1
Xhold273 instance_2.data\[0\]\[20\] VGND VGND VPWR VPWR net423 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_5_243 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_37_Left_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_76_919 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_86_1015 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_84_996 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_11_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_63_261 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xinput8 wdata[13] VGND VGND VPWR VPWR net8 sky130_fd_sc_hd__buf_1
XTAP_TAPCELL_ROW_47_643 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_19_378 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_86_375 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_74_515 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3901_ _1913_ VGND VGND VPWR VPWR _0691_ sky130_fd_sc_hd__clkbuf_1
X_3832_ _1877_ VGND VGND VPWR VPWR _0658_ sky130_fd_sc_hd__clkbuf_1
X_3763_ _1840_ VGND VGND VPWR VPWR _0626_ sky130_fd_sc_hd__clkbuf_1
X_3694_ net184 _1120_ _1795_ VGND VGND VPWR VPWR _1804_ sky130_fd_sc_hd__mux2_1
X_2714_ net714 _1280_ _1264_ VGND VGND VPWR VPWR _1281_ sky130_fd_sc_hd__mux2_1
X_2645_ _1227_ VGND VGND VPWR VPWR _0121_ sky130_fd_sc_hd__clkbuf_1
X_2576_ instance_1.data\[0\]\[34\] instance_1.data\[1\]\[34\] instance_1.data\[2\]\[34\]
+ instance_1.data\[3\]\[34\] _1143_ _1156_ VGND VGND VPWR VPWR _1174_ sky130_fd_sc_hd__mux4_1
XFILLER_0_77_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_10_342 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4315_ clknet_leaf_4_clk _0355_ VGND VGND VPWR VPWR instance_1.data\[3\]\[67\] sky130_fd_sc_hd__dfxtp_1
X_4246_ clknet_leaf_22_clk _0286_ VGND VGND VPWR VPWR instance_2.data\[0\]\[70\] sky130_fd_sc_hd__dfxtp_1
X_4177_ clknet_leaf_0_clk _0217_ VGND VGND VPWR VPWR instance_2.data\[0\]\[1\] sky130_fd_sc_hd__dfxtp_1
X_3128_ _1506_ VGND VGND VPWR VPWR _0325_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_69_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3059_ _1470_ VGND VGND VPWR VPWR _0292_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_81_966 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_92_356 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_18_431 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_92_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_18_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_60_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_92_1085 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_92_1074 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_44_613 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_16_348 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_52_690 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_11_128 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2430_ _1061_ VGND VGND VPWR VPWR _0072_ sky130_fd_sc_hd__clkbuf_1
X_2361_ _1007_ VGND VGND VPWR VPWR _0057_ sky130_fd_sc_hd__clkbuf_1
X_4100_ clknet_leaf_4_clk _0140_ VGND VGND VPWR VPWR instance_1.data\[1\]\[68\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_47_33 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2292_ instance_2.data\[0\]\[42\] instance_2.data\[1\]\[42\] instance_2.data\[2\]\[42\]
+ instance_2.data\[3\]\[42\] _0923_ _0936_ VGND VGND VPWR VPWR _0954_ sky130_fd_sc_hd__mux4_1
X_4031_ clknet_leaf_54_clk _0071_ VGND VGND VPWR VPWR instance_2.data\[2\]\[71\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_37_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_47_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_78_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_59_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_63_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3815_ _1868_ VGND VGND VPWR VPWR _0650_ sky130_fd_sc_hd__clkbuf_1
X_3746_ _1831_ VGND VGND VPWR VPWR _0618_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_42_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3677_ net150 VGND VGND VPWR VPWR _1795_ sky130_fd_sc_hd__buf_4
Xoutput120 net120 VGND VGND VPWR VPWR rdata[49] sky130_fd_sc_hd__clkbuf_4
X_2628_ _1214_ VGND VGND VPWR VPWR _0117_ sky130_fd_sc_hd__clkbuf_1
Xoutput142 net142 VGND VGND VPWR VPWR rdata[69] sky130_fd_sc_hd__clkbuf_4
Xoutput131 net131 VGND VGND VPWR VPWR rdata[59] sky130_fd_sc_hd__clkbuf_4
X_2559_ net27 _1160_ _1131_ VGND VGND VPWR VPWR _1161_ sky130_fd_sc_hd__mux2_1
X_4229_ clknet_leaf_8_clk _0269_ VGND VGND VPWR VPWR instance_2.data\[0\]\[53\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_58_749 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_18_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_18_294 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_21_395 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_33_231 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_33_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_29_473 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4580_ clknet_leaf_25_clk _0620_ VGND VGND VPWR VPWR instance_1.data\[0\]\[44\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_71_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_71_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3600_ _1754_ VGND VGND VPWR VPWR _0549_ sky130_fd_sc_hd__clkbuf_1
Xinput11 wdata[16] VGND VGND VPWR VPWR net11 sky130_fd_sc_hd__buf_1
Xinput22 wdata[26] VGND VGND VPWR VPWR net22 sky130_fd_sc_hd__buf_1
Xinput44 wdata[46] VGND VGND VPWR VPWR net44 sky130_fd_sc_hd__buf_1
Xinput33 wdata[36] VGND VGND VPWR VPWR net33 sky130_fd_sc_hd__buf_1
Xinput55 wdata[56] VGND VGND VPWR VPWR net55 sky130_fd_sc_hd__buf_1
X_3531_ _1718_ VGND VGND VPWR VPWR _0516_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_24_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_52_551 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xinput66 wdata[66] VGND VGND VPWR VPWR net66 sky130_fd_sc_hd__buf_1
X_3462_ _1682_ VGND VGND VPWR VPWR _0483_ sky130_fd_sc_hd__clkbuf_1
X_3393_ net210 _1124_ _1636_ VGND VGND VPWR VPWR _1646_ sky130_fd_sc_hd__mux2_1
X_2413_ _1047_ VGND VGND VPWR VPWR _0069_ sky130_fd_sc_hd__clkbuf_1
X_2344_ _0994_ VGND VGND VPWR VPWR _0053_ sky130_fd_sc_hd__clkbuf_1
X_2275_ _0940_ net35 _0910_ VGND VGND VPWR VPWR _0941_ sky130_fd_sc_hd__mux2_1
X_4014_ clknet_leaf_8_clk _0054_ VGND VGND VPWR VPWR instance_2.data\[2\]\[54\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_55_719 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_90_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_90_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_47_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_63_796 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_35_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_62_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3729_ _1822_ VGND VGND VPWR VPWR _0610_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_26_443 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_80_178 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2060_ instance_1.rdata\[54\] instance_2.rdata\[54\] _0777_ VGND VGND VPWR VPWR _0782_
+ sky130_fd_sc_hd__mux2_1
XFILLER_0_44_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_44_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_29_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2962_ _0918_ net835 _1417_ VGND VGND VPWR VPWR _1419_ sky130_fd_sc_hd__mux2_1
XFILLER_0_17_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_60_766 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2893_ _1381_ VGND VGND VPWR VPWR _0215_ sky130_fd_sc_hd__clkbuf_1
X_4632_ clknet_leaf_53_clk _0672_ VGND VGND VPWR VPWR instance_2.data\[3\]\[24\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_56_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold603 instance_2.data\[2\]\[24\] VGND VGND VPWR VPWR net753 sky130_fd_sc_hd__dlygate4sd3_1
X_4563_ clknet_leaf_34_clk _0603_ VGND VGND VPWR VPWR instance_1.data\[0\]\[27\] sky130_fd_sc_hd__dfxtp_1
Xhold636 instance_2.data\[0\]\[36\] VGND VGND VPWR VPWR net786 sky130_fd_sc_hd__dlygate4sd3_1
X_3514_ _1709_ VGND VGND VPWR VPWR _0508_ sky130_fd_sc_hd__clkbuf_1
Xhold625 instance_1.data\[0\]\[62\] VGND VGND VPWR VPWR net775 sky130_fd_sc_hd__dlygate4sd3_1
Xhold614 instance_2.data\[0\]\[32\] VGND VGND VPWR VPWR net764 sky130_fd_sc_hd__dlygate4sd3_1
X_4494_ clknet_leaf_36_clk _0534_ VGND VGND VPWR VPWR instance_2.rdata\[30\] sky130_fd_sc_hd__dfxtp_1
X_3445_ _1673_ VGND VGND VPWR VPWR _0475_ sky130_fd_sc_hd__clkbuf_1
Xhold647 instance_2.data\[0\]\[34\] VGND VGND VPWR VPWR net797 sky130_fd_sc_hd__dlygate4sd3_1
Xhold658 instance_2.rdata\[28\] VGND VGND VPWR VPWR net808 sky130_fd_sc_hd__dlygate4sd3_1
Xhold669 instance_2.data\[1\]\[68\] VGND VGND VPWR VPWR net819 sky130_fd_sc_hd__dlygate4sd3_1
X_3376_ _1637_ VGND VGND VPWR VPWR _0442_ sky130_fd_sc_hd__clkbuf_1
X_2327_ instance_2.data\[0\]\[50\] instance_2.data\[1\]\[50\] instance_2.data\[2\]\[50\]
+ instance_2.data\[3\]\[50\] _0957_ _0970_ VGND VGND VPWR VPWR _0981_ sky130_fd_sc_hd__mux4_1
X_2258_ _0927_ net31 _0910_ VGND VGND VPWR VPWR _0928_ sky130_fd_sc_hd__mux2_1
XFILLER_0_33_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_68_844 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2189_ _0874_ VGND VGND VPWR VPWR _0018_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_79_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_90_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_16_551 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_50_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_62_156 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_7_294 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_31_490 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_50_318 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_89_1046 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_14_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_81_498 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_53_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_1_415 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_39_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3230_ _1560_ VGND VGND VPWR VPWR _0373_ sky130_fd_sc_hd__clkbuf_1
X_3161_ net573 _1240_ _1520_ VGND VGND VPWR VPWR _1524_ sky130_fd_sc_hd__mux2_1
X_2112_ instance_2.data\[0\]\[1\] instance_2.data\[1\]\[1\] instance_2.data\[2\]\[1\]
+ instance_2.data\[3\]\[1\] _0802_ _0804_ VGND VGND VPWR VPWR _0815_ sky130_fd_sc_hd__mux4_1
X_3092_ net592 _1127_ _1487_ VGND VGND VPWR VPWR _1488_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_65_814 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2043_ instance_1.rdata\[46\] instance_2.rdata\[46\] _0766_ VGND VGND VPWR VPWR _0773_
+ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_37_549 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_76_259 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3994_ clknet_leaf_32_clk _0034_ VGND VGND VPWR VPWR instance_2.data\[2\]\[34\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_73_891 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_9_537 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_72_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2945_ _0891_ net636 _1406_ VGND VGND VPWR VPWR _1410_ sky130_fd_sc_hd__mux2_1
X_2876_ net752 _1027_ _1369_ VGND VGND VPWR VPWR _1373_ sky130_fd_sc_hd__mux2_1
X_4615_ clknet_leaf_56_clk _0655_ VGND VGND VPWR VPWR instance_2.data\[3\]\[7\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_32_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_32_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_4_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4546_ clknet_leaf_48_clk _0586_ VGND VGND VPWR VPWR instance_1.data\[0\]\[10\] sky130_fd_sc_hd__dfxtp_1
Xhold411 instance_1.rdata\[17\] VGND VGND VPWR VPWR net561 sky130_fd_sc_hd__dlygate4sd3_1
Xhold400 instance_2.data\[3\]\[63\] VGND VGND VPWR VPWR net550 sky130_fd_sc_hd__dlygate4sd3_1
Xhold444 instance_1.data\[1\]\[6\] VGND VGND VPWR VPWR net594 sky130_fd_sc_hd__dlygate4sd3_1
Xhold433 instance_1.data\[2\]\[6\] VGND VGND VPWR VPWR net583 sky130_fd_sc_hd__dlygate4sd3_1
Xhold422 instance_2.data\[2\]\[20\] VGND VGND VPWR VPWR net572 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_40_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4477_ clknet_leaf_46_clk _0517_ VGND VGND VPWR VPWR instance_2.rdata\[13\] sky130_fd_sc_hd__dfxtp_1
Xhold477 instance_2.data\[3\]\[59\] VGND VGND VPWR VPWR net627 sky130_fd_sc_hd__dlygate4sd3_1
Xhold466 instance_2.data\[0\]\[52\] VGND VGND VPWR VPWR net616 sky130_fd_sc_hd__dlygate4sd3_1
Xhold455 instance_2.rdata\[54\] VGND VGND VPWR VPWR net605 sky130_fd_sc_hd__dlygate4sd3_1
X_3428_ _1664_ VGND VGND VPWR VPWR _0467_ sky130_fd_sc_hd__clkbuf_1
Xhold488 instance_1.data\[0\]\[25\] VGND VGND VPWR VPWR net638 sky130_fd_sc_hd__dlygate4sd3_1
Xhold499 instance_1.data\[1\]\[31\] VGND VGND VPWR VPWR net649 sky130_fd_sc_hd__dlygate4sd3_1
X_3359_ _1628_ VGND VGND VPWR VPWR _0434_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_0_492 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_0_196 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_75_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_63_443 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_90_273 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_16_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_8_274 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_34_519 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_54_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_70_861 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2730_ net383 _1292_ _1264_ VGND VGND VPWR VPWR _1293_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_42_596 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2661_ net52 _1239_ _1233_ VGND VGND VPWR VPWR _1240_ sky130_fd_sc_hd__mux2_1
X_4400_ clknet_leaf_57_clk _0440_ VGND VGND VPWR VPWR instance_1.data\[2\]\[8\] sky130_fd_sc_hd__dfxtp_1
X_2592_ _1186_ VGND VGND VPWR VPWR _0109_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_41_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4331_ clknet_leaf_48_clk _0371_ VGND VGND VPWR VPWR instance_1.rdata\[11\] sky130_fd_sc_hd__dfxtp_1
X_4262_ clknet_leaf_45_clk _0302_ VGND VGND VPWR VPWR instance_1.data\[3\]\[14\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_5_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3213_ _1551_ VGND VGND VPWR VPWR _0365_ sky130_fd_sc_hd__clkbuf_1
X_4193_ clknet_leaf_40_clk _0233_ VGND VGND VPWR VPWR instance_2.data\[0\]\[17\] sky130_fd_sc_hd__dfxtp_1
X_3144_ net521 _1213_ _1509_ VGND VGND VPWR VPWR _1515_ sky130_fd_sc_hd__mux2_1
X_3075_ net354 _1101_ _1476_ VGND VGND VPWR VPWR _1479_ sky130_fd_sc_hd__mux2_1
X_2026_ instance_1.rdata\[38\] instance_2.rdata\[38\] _0755_ VGND VGND VPWR VPWR _0764_
+ sky130_fd_sc_hd__mux2_1
XFILLER_0_77_524 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_92_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3977_ clknet_leaf_51_clk _0017_ VGND VGND VPWR VPWR instance_2.data\[2\]\[17\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_57_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_17_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2928_ _0863_ net793 _1395_ VGND VGND VPWR VPWR _1401_ sky130_fd_sc_hd__mux2_1
XFILLER_0_32_126 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2859_ net794 _0999_ _1358_ VGND VGND VPWR VPWR _1364_ sky130_fd_sc_hd__mux2_1
XFILLER_0_13_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xhold241 instance_2.data\[2\]\[9\] VGND VGND VPWR VPWR net391 sky130_fd_sc_hd__dlygate4sd3_1
Xhold252 instance_1.data\[3\]\[68\] VGND VGND VPWR VPWR net402 sky130_fd_sc_hd__dlygate4sd3_1
X_4529_ clknet_leaf_3_clk _0569_ VGND VGND VPWR VPWR instance_2.rdata\[65\] sky130_fd_sc_hd__dfxtp_1
Xhold230 instance_2.data\[1\]\[23\] VGND VGND VPWR VPWR net380 sky130_fd_sc_hd__dlygate4sd3_1
Xhold296 instance_1.rdata\[46\] VGND VGND VPWR VPWR net446 sky130_fd_sc_hd__dlygate4sd3_1
Xhold285 instance_2.data\[2\]\[14\] VGND VGND VPWR VPWR net435 sky130_fd_sc_hd__dlygate4sd3_1
Xhold274 instance_2.data\[3\]\[43\] VGND VGND VPWR VPWR net424 sky130_fd_sc_hd__dlygate4sd3_1
Xhold263 instance_2.data\[1\]\[43\] VGND VGND VPWR VPWR net413 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_5_244 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_86_1016 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_84_997 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_83_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_48_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_11_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_63_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_36_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xinput9 wdata[14] VGND VGND VPWR VPWR net9 sky130_fd_sc_hd__buf_1
XTAP_TAPCELL_ROW_47_644 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_19_379 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_86_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3900_ net424 _0959_ _1909_ VGND VGND VPWR VPWR _1913_ sky130_fd_sc_hd__mux2_1
X_3831_ net471 _0846_ _1876_ VGND VGND VPWR VPWR _1877_ sky130_fd_sc_hd__mux2_1
X_3762_ net434 _1229_ _1839_ VGND VGND VPWR VPWR _1840_ sky130_fd_sc_hd__mux2_1
XFILLER_0_27_432 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_39_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_6_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_27_476 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3693_ _1803_ VGND VGND VPWR VPWR _0593_ sky130_fd_sc_hd__clkbuf_1
X_2713_ net65 _1279_ _1267_ VGND VGND VPWR VPWR _1280_ sky130_fd_sc_hd__mux2_1
X_2644_ net162 _1226_ _1196_ VGND VGND VPWR VPWR _1227_ sky130_fd_sc_hd__mux2_1
XFILLER_0_2_510 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2575_ _1173_ VGND VGND VPWR VPWR _0105_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_10_290 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_10_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4314_ clknet_leaf_0_clk _0354_ VGND VGND VPWR VPWR instance_1.data\[3\]\[66\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_10_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4245_ clknet_leaf_6_clk _0285_ VGND VGND VPWR VPWR instance_2.data\[0\]\[69\] sky130_fd_sc_hd__dfxtp_1
X_4176_ clknet_leaf_0_clk _0216_ VGND VGND VPWR VPWR instance_2.data\[0\]\[0\] sky130_fd_sc_hd__dfxtp_1
X_3127_ net267 _1185_ _1498_ VGND VGND VPWR VPWR _1506_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_2_214 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_89_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3058_ net729 _1073_ _1465_ VGND VGND VPWR VPWR _1470_ sky130_fd_sc_hd__mux2_1
Xclkbuf_leaf_62_clk clknet_3_0__leaf_clk VGND VGND VPWR VPWR clknet_leaf_62_clk sky130_fd_sc_hd__clkbuf_8
X_2009_ _0721_ VGND VGND VPWR VPWR _0755_ sky130_fd_sc_hd__buf_4
XFILLER_0_92_324 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_81_967 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_18_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_41_490 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_92_1086 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_92_1075 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_44_614 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_leaf_53_clk clknet_3_1__leaf_clk VGND VGND VPWR VPWR clknet_leaf_53_clk sky130_fd_sc_hd__clkbuf_8
XTAP_TAPCELL_ROW_16_349 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_22_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_52_691 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_51_287 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2360_ net773 _1006_ _0983_ VGND VGND VPWR VPWR _1007_ sky130_fd_sc_hd__mux2_1
XFILLER_0_47_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2291_ _0953_ VGND VGND VPWR VPWR _0041_ sky130_fd_sc_hd__clkbuf_1
XPHY_EDGE_ROW_10_Right_10 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4030_ clknet_leaf_6_clk _0070_ VGND VGND VPWR VPWR instance_2.data\[2\]\[70\] sky130_fd_sc_hd__dfxtp_1
XPHY_EDGE_ROW_56_Left_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkbuf_leaf_44_clk clknet_3_5__leaf_clk VGND VGND VPWR VPWR clknet_leaf_44_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_0_47_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_74_324 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_19_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_15_402 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3814_ net360 _0819_ _1865_ VGND VGND VPWR VPWR _1868_ sky130_fd_sc_hd__mux2_1
X_3745_ net398 _1203_ _1828_ VGND VGND VPWR VPWR _1831_ sky130_fd_sc_hd__mux2_1
XFILLER_0_88_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput110 net110 VGND VGND VPWR VPWR rdata[3] sky130_fd_sc_hd__clkbuf_4
X_3676_ _1794_ VGND VGND VPWR VPWR _0585_ sky130_fd_sc_hd__clkbuf_1
XPHY_EDGE_ROW_65_Left_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_88_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2627_ net222 _1213_ _1196_ VGND VGND VPWR VPWR _1214_ sky130_fd_sc_hd__mux2_1
Xoutput143 net143 VGND VGND VPWR VPWR rdata[6] sky130_fd_sc_hd__clkbuf_4
Xoutput132 net132 VGND VGND VPWR VPWR rdata[5] sky130_fd_sc_hd__clkbuf_4
Xoutput121 net121 VGND VGND VPWR VPWR rdata[4] sky130_fd_sc_hd__clkbuf_4
XFILLER_0_63_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2558_ instance_1.data\[0\]\[30\] instance_1.data\[1\]\[30\] instance_1.data\[2\]\[30\]
+ instance_1.data\[3\]\[30\] _1143_ _1156_ VGND VGND VPWR VPWR _1160_ sky130_fd_sc_hd__mux4_1
X_2489_ net9 _1106_ _1097_ VGND VGND VPWR VPWR _1107_ sky130_fd_sc_hd__mux2_1
X_4228_ clknet_leaf_7_clk _0268_ VGND VGND VPWR VPWR instance_2.data\[0\]\[52\] sky130_fd_sc_hd__dfxtp_1
XPHY_EDGE_ROW_74_Left_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4159_ clknet_leaf_11_clk _0199_ VGND VGND VPWR VPWR instance_2.data\[1\]\[55\] sky130_fd_sc_hd__dfxtp_1
Xclkbuf_leaf_35_clk clknet_3_7__leaf_clk VGND VGND VPWR VPWR clknet_leaf_35_clk sky130_fd_sc_hd__clkbuf_8
XTAP_TAPCELL_ROW_13_319 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_83_Left_176 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_21_396 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_92_Left_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_17_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_29_474 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_leaf_26_clk clknet_3_6__leaf_clk VGND VGND VPWR VPWR clknet_leaf_26_clk sky130_fd_sc_hd__clkbuf_8
XPHY_EDGE_ROW_1_Left_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_29_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_29_549 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_71_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_56_379 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xinput12 wdata[17] VGND VGND VPWR VPWR net12 sky130_fd_sc_hd__buf_1
XFILLER_0_52_530 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_64_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xinput34 wdata[37] VGND VGND VPWR VPWR net34 sky130_fd_sc_hd__buf_1
Xinput45 wdata[47] VGND VGND VPWR VPWR net45 sky130_fd_sc_hd__buf_1
X_3530_ _0852_ net860 _1715_ VGND VGND VPWR VPWR _1718_ sky130_fd_sc_hd__mux2_1
Xinput23 wdata[27] VGND VGND VPWR VPWR net23 sky130_fd_sc_hd__buf_1
Xinput56 wdata[57] VGND VGND VPWR VPWR net56 sky130_fd_sc_hd__buf_1
Xinput67 wdata[67] VGND VGND VPWR VPWR net67 sky130_fd_sc_hd__buf_1
X_3461_ net329 _1234_ _1680_ VGND VGND VPWR VPWR _1682_ sky130_fd_sc_hd__mux2_1
X_3392_ _1645_ VGND VGND VPWR VPWR _0450_ sky130_fd_sc_hd__clkbuf_1
X_2412_ net473 _1046_ _1017_ VGND VGND VPWR VPWR _1047_ sky130_fd_sc_hd__mux2_1
X_2343_ net452 _0993_ _0983_ VGND VGND VPWR VPWR _0994_ sky130_fd_sc_hd__mux2_1
X_2274_ instance_2.data\[0\]\[38\] instance_2.data\[1\]\[38\] instance_2.data\[2\]\[38\]
+ instance_2.data\[3\]\[38\] _0923_ _0936_ VGND VGND VPWR VPWR _0940_ sky130_fd_sc_hd__mux4_1
X_4013_ clknet_leaf_12_clk _0053_ VGND VGND VPWR VPWR instance_2.data\[2\]\[53\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_90_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_leaf_17_clk clknet_3_3__leaf_clk VGND VGND VPWR VPWR clknet_leaf_17_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_0_90_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_63_797 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_7_476 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_15_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1989_ instance_1.rdata\[20\] instance_2.rdata\[20\] _0744_ VGND VGND VPWR VPWR _0745_
+ sky130_fd_sc_hd__mux2_1
X_3728_ net657 _1175_ _1817_ VGND VGND VPWR VPWR _1822_ sky130_fd_sc_hd__mux2_1
X_3659_ net274 _1064_ _1784_ VGND VGND VPWR VPWR _1786_ sky130_fd_sc_hd__mux2_1
XFILLER_0_30_224 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_26_444 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_53_316 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_34_541 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_61_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_88_224 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_29_324 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2961_ _1418_ VGND VGND VPWR VPWR _0246_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_84_474 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2892_ net215 _1052_ _1302_ VGND VGND VPWR VPWR _1381_ sky130_fd_sc_hd__mux2_1
X_4631_ clknet_leaf_38_clk _0671_ VGND VGND VPWR VPWR instance_2.data\[3\]\[23\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_60_767 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_71_146 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_4_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_25_541 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4562_ clknet_leaf_41_clk _0602_ VGND VGND VPWR VPWR instance_1.data\[0\]\[26\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_52_371 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_69_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xhold604 instance_2.rdata\[38\] VGND VGND VPWR VPWR net754 sky130_fd_sc_hd__dlygate4sd3_1
Xhold615 instance_1.rdata\[44\] VGND VGND VPWR VPWR net765 sky130_fd_sc_hd__dlygate4sd3_1
X_3513_ _0825_ net725 _1704_ VGND VGND VPWR VPWR _1709_ sky130_fd_sc_hd__mux2_1
Xhold626 instance_1.data\[3\]\[71\] VGND VGND VPWR VPWR net776 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_40_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4493_ clknet_leaf_37_clk _0533_ VGND VGND VPWR VPWR instance_2.rdata\[29\] sky130_fd_sc_hd__dfxtp_1
X_3444_ net196 _1206_ _1669_ VGND VGND VPWR VPWR _1673_ sky130_fd_sc_hd__mux2_1
Xhold659 instance_2.rdata\[23\] VGND VGND VPWR VPWR net809 sky130_fd_sc_hd__dlygate4sd3_1
Xhold648 instance_2.data\[0\]\[63\] VGND VGND VPWR VPWR net798 sky130_fd_sc_hd__dlygate4sd3_1
Xclkbuf_leaf_6_clk clknet_3_3__leaf_clk VGND VGND VPWR VPWR clknet_leaf_6_clk sky130_fd_sc_hd__clkbuf_8
Xhold637 instance_2.rdata\[53\] VGND VGND VPWR VPWR net787 sky130_fd_sc_hd__dlygate4sd3_1
X_3375_ net204 _1093_ _1636_ VGND VGND VPWR VPWR _1637_ sky130_fd_sc_hd__mux2_1
XFILLER_0_85_64 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2326_ _0980_ VGND VGND VPWR VPWR _0049_ sky130_fd_sc_hd__clkbuf_1
X_2257_ instance_2.data\[0\]\[34\] instance_2.data\[1\]\[34\] instance_2.data\[2\]\[34\]
+ instance_2.data\[3\]\[34\] _0923_ _0902_ VGND VGND VPWR VPWR _0927_ sky130_fd_sc_hd__mux4_1
XTAP_TAPCELL_ROW_68_845 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2188_ net340 _0873_ _0847_ VGND VGND VPWR VPWR _0874_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_23_414 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_90_433 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_62_102 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_62_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_90_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_31_491 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_62_168 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_31_522 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_89_1047 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_14_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_38_154 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_66_496 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_22_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3160_ _1523_ VGND VGND VPWR VPWR _0340_ sky130_fd_sc_hd__clkbuf_1
Xhold1 instance_1.data\[2\]\[12\] VGND VGND VPWR VPWR net151 sky130_fd_sc_hd__dlygate4sd3_1
X_2111_ _0814_ VGND VGND VPWR VPWR _0000_ sky130_fd_sc_hd__clkbuf_1
X_3091_ _1464_ VGND VGND VPWR VPWR _1487_ sky130_fd_sc_hd__buf_4
X_2042_ _0772_ VGND VGND VPWR VPWR net116 sky130_fd_sc_hd__buf_1
XTAP_TAPCELL_ROW_65_815 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_8_Right_8 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_73_892 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_9_549 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_57_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3993_ clknet_leaf_32_clk _0033_ VGND VGND VPWR VPWR instance_2.data\[2\]\[33\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_72_400 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_305 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2944_ _1409_ VGND VGND VPWR VPWR _0238_ sky130_fd_sc_hd__clkbuf_1
X_2875_ _1372_ VGND VGND VPWR VPWR _0206_ sky130_fd_sc_hd__clkbuf_1
X_4614_ clknet_leaf_59_clk _0654_ VGND VGND VPWR VPWR instance_2.data\[3\]\[6\] sky130_fd_sc_hd__dfxtp_1
X_4545_ clknet_leaf_57_clk _0585_ VGND VGND VPWR VPWR instance_1.data\[0\]\[9\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_20_70 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xhold401 instance_2.data\[2\]\[5\] VGND VGND VPWR VPWR net551 sky130_fd_sc_hd__dlygate4sd3_1
Xhold423 instance_1.data\[3\]\[53\] VGND VGND VPWR VPWR net573 sky130_fd_sc_hd__dlygate4sd3_1
Xhold445 instance_2.data\[3\]\[7\] VGND VGND VPWR VPWR net595 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_20_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold412 instance_1.rdata\[61\] VGND VGND VPWR VPWR net562 sky130_fd_sc_hd__dlygate4sd3_1
Xhold434 instance_2.data\[0\]\[35\] VGND VGND VPWR VPWR net584 sky130_fd_sc_hd__dlygate4sd3_1
X_4476_ clknet_leaf_48_clk _0516_ VGND VGND VPWR VPWR instance_2.rdata\[12\] sky130_fd_sc_hd__dfxtp_1
Xhold467 instance_2.data\[3\]\[69\] VGND VGND VPWR VPWR net617 sky130_fd_sc_hd__dlygate4sd3_1
Xhold478 instance_1.rdata\[27\] VGND VGND VPWR VPWR net628 sky130_fd_sc_hd__dlygate4sd3_1
Xhold456 instance_2.data\[3\]\[31\] VGND VGND VPWR VPWR net606 sky130_fd_sc_hd__dlygate4sd3_1
X_3427_ net658 _1179_ _1658_ VGND VGND VPWR VPWR _1664_ sky130_fd_sc_hd__mux2_1
XPHY_EDGE_ROW_39_Right_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold489 instance_1.data\[3\]\[26\] VGND VGND VPWR VPWR net639 sky130_fd_sc_hd__dlygate4sd3_1
X_3358_ net774 _1067_ _1625_ VGND VGND VPWR VPWR _1628_ sky130_fd_sc_hd__mux2_1
X_2309_ instance_2.data\[0\]\[46\] instance_2.data\[1\]\[46\] instance_2.data\[2\]\[46\]
+ instance_2.data\[3\]\[46\] _0957_ _0936_ VGND VGND VPWR VPWR _0967_ sky130_fd_sc_hd__mux4_1
X_3289_ _1591_ VGND VGND VPWR VPWR _0401_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_0_186 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_197 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_48_Right_48 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_75_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_90_285 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_50_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_57_Right_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_8_275 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_25_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_86_514 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_66_Right_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_6_508 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_70_862 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_42_597 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_81_252 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2660_ instance_1.data\[0\]\[53\] instance_1.data\[1\]\[53\] instance_1.data\[2\]\[53\]
+ instance_1.data\[3\]\[53\] _1211_ _1224_ VGND VGND VPWR VPWR _1239_ sky130_fd_sc_hd__mux4_1
XFILLER_0_26_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_41_116 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2591_ net411 _1185_ _1162_ VGND VGND VPWR VPWR _1186_ sky130_fd_sc_hd__mux2_1
XPHY_EDGE_ROW_75_Right_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4330_ clknet_leaf_50_clk _0370_ VGND VGND VPWR VPWR instance_1.rdata\[10\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_22_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4261_ clknet_leaf_45_clk _0301_ VGND VGND VPWR VPWR instance_1.data\[3\]\[13\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_5_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3212_ net335 _1076_ _1545_ VGND VGND VPWR VPWR _1551_ sky130_fd_sc_hd__mux2_1
X_4192_ clknet_leaf_47_clk _0232_ VGND VGND VPWR VPWR instance_2.data\[0\]\[16\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_66_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3143_ _1514_ VGND VGND VPWR VPWR _0332_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_78_940 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_84_Right_84 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3074_ _1478_ VGND VGND VPWR VPWR _0299_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_89_374 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2025_ _0763_ VGND VGND VPWR VPWR net107 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_92_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3976_ clknet_leaf_47_clk _0016_ VGND VGND VPWR VPWR instance_2.data\[2\]\[16\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_9_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2927_ _1400_ VGND VGND VPWR VPWR _0230_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_17_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_5_541 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_72_296 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_32_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2858_ _1363_ VGND VGND VPWR VPWR _0198_ sky130_fd_sc_hd__clkbuf_1
Xhold220 instance_1.rdata\[37\] VGND VGND VPWR VPWR net370 sky130_fd_sc_hd__dlygate4sd3_1
X_2789_ _1327_ VGND VGND VPWR VPWR _0165_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_60_458 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold253 instance_1.rdata\[38\] VGND VGND VPWR VPWR net403 sky130_fd_sc_hd__dlygate4sd3_1
Xhold242 instance_1.data\[2\]\[44\] VGND VGND VPWR VPWR net392 sky130_fd_sc_hd__dlygate4sd3_1
X_4528_ clknet_leaf_3_clk _0568_ VGND VGND VPWR VPWR instance_2.rdata\[64\] sky130_fd_sc_hd__dfxtp_1
Xhold231 instance_2.data\[1\]\[42\] VGND VGND VPWR VPWR net381 sky130_fd_sc_hd__dlygate4sd3_1
Xhold264 instance_1.data\[2\]\[18\] VGND VGND VPWR VPWR net414 sky130_fd_sc_hd__dlygate4sd3_1
Xhold286 instance_2.rdata\[19\] VGND VGND VPWR VPWR net436 sky130_fd_sc_hd__dlygate4sd3_1
X_4459_ clknet_leaf_4_clk _0499_ VGND VGND VPWR VPWR instance_1.data\[2\]\[67\] sky130_fd_sc_hd__dfxtp_1
Xhold275 instance_2.data\[3\]\[32\] VGND VGND VPWR VPWR net425 sky130_fd_sc_hd__dlygate4sd3_1
Xhold297 instance_1.data\[1\]\[57\] VGND VGND VPWR VPWR net447 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_5_245 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_86_1017 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_84_998 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_83_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_127 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_23_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_75_910 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_47_645 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_86_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_52_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3830_ _1864_ VGND VGND VPWR VPWR _1876_ sky130_fd_sc_hd__buf_4
XFILLER_0_46_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3761_ _1783_ VGND VGND VPWR VPWR _1839_ sky130_fd_sc_hd__buf_4
XFILLER_0_6_338 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2712_ instance_1.data\[0\]\[65\] instance_1.data\[1\]\[65\] instance_1.data\[2\]\[65\]
+ instance_1.data\[3\]\[65\] _0802_ _1258_ VGND VGND VPWR VPWR _1279_ sky130_fd_sc_hd__mux4_1
X_3692_ net618 _1117_ _1795_ VGND VGND VPWR VPWR _1803_ sky130_fd_sc_hd__mux2_1
X_2643_ net47 _1225_ _1199_ VGND VGND VPWR VPWR _1226_ sky130_fd_sc_hd__mux2_1
XFILLER_0_2_522 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_2_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_42_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_77_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2574_ net396 _1172_ _1162_ VGND VGND VPWR VPWR _1173_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_10_291 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4313_ clknet_leaf_3_clk _0353_ VGND VGND VPWR VPWR instance_1.data\[3\]\[65\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_10_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4244_ clknet_leaf_7_clk _0284_ VGND VGND VPWR VPWR instance_2.data\[0\]\[68\] sky130_fd_sc_hd__dfxtp_1
X_4175_ clknet_leaf_53_clk _0215_ VGND VGND VPWR VPWR instance_2.data\[1\]\[71\] sky130_fd_sc_hd__dfxtp_1
X_3126_ _1505_ VGND VGND VPWR VPWR _0324_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_2_215 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3057_ _1469_ VGND VGND VPWR VPWR _0291_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_26_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_89_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2008_ _0754_ VGND VGND VPWR VPWR net98 sky130_fd_sc_hd__buf_1
XTAP_TAPCELL_ROW_81_968 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_45_230 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_18_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3959_ _1943_ VGND VGND VPWR VPWR _0719_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_5_371 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_92_1087 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_92_1076 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_44_615 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_22_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_52_692 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_51_211 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_51_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2290_ net305 _0952_ _0949_ VGND VGND VPWR VPWR _0953_ sky130_fd_sc_hd__mux2_1
XFILLER_0_2_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_47_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3813_ _1867_ VGND VGND VPWR VPWR _0649_ sky130_fd_sc_hd__clkbuf_1
X_3744_ _1830_ VGND VGND VPWR VPWR _0617_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_42_222 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_12_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3675_ net242 _1090_ _1784_ VGND VGND VPWR VPWR _1794_ sky130_fd_sc_hd__mux2_1
XFILLER_0_88_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2626_ net43 _1212_ _1199_ VGND VGND VPWR VPWR _1213_ sky130_fd_sc_hd__mux2_1
Xoutput100 net100 VGND VGND VPWR VPWR rdata[30] sky130_fd_sc_hd__clkbuf_4
Xoutput111 net111 VGND VGND VPWR VPWR rdata[40] sky130_fd_sc_hd__clkbuf_4
Xoutput122 net122 VGND VGND VPWR VPWR rdata[50] sky130_fd_sc_hd__clkbuf_4
XFILLER_0_88_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_2_374 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_23_480 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xoutput133 net133 VGND VGND VPWR VPWR rdata[60] sky130_fd_sc_hd__clkbuf_4
XFILLER_0_10_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xoutput144 net144 VGND VGND VPWR VPWR rdata[70] sky130_fd_sc_hd__clkbuf_4
X_2557_ _1159_ VGND VGND VPWR VPWR _0101_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_56_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2488_ instance_1.data\[0\]\[14\] instance_1.data\[1\]\[14\] instance_1.data\[2\]\[14\]
+ instance_1.data\[3\]\[14\] _1075_ _1088_ VGND VGND VPWR VPWR _1106_ sky130_fd_sc_hd__mux4_1
X_4227_ clknet_leaf_8_clk _0267_ VGND VGND VPWR VPWR instance_2.data\[0\]\[51\] sky130_fd_sc_hd__dfxtp_1
X_4158_ clknet_leaf_8_clk _0198_ VGND VGND VPWR VPWR instance_2.data\[1\]\[54\] sky130_fd_sc_hd__dfxtp_1
X_4089_ clknet_leaf_14_clk _0129_ VGND VGND VPWR VPWR instance_1.data\[1\]\[57\] sky130_fd_sc_hd__dfxtp_1
X_3109_ _1496_ VGND VGND VPWR VPWR _0316_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_92_155 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_80_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_80_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_92_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_73_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_21_397 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_33_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_14_480 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_17_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_57_740 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_29_475 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_29_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_56_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_68_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_68_174 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_83_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_68_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xinput13 wdata[18] VGND VGND VPWR VPWR net13 sky130_fd_sc_hd__buf_1
Xinput35 wdata[38] VGND VGND VPWR VPWR net35 sky130_fd_sc_hd__buf_1
Xinput46 wdata[48] VGND VGND VPWR VPWR net46 sky130_fd_sc_hd__buf_1
Xinput24 wdata[28] VGND VGND VPWR VPWR net24 sky130_fd_sc_hd__buf_1
Xinput68 wdata[68] VGND VGND VPWR VPWR net68 sky130_fd_sc_hd__dlymetal6s2s_1
Xinput57 wdata[58] VGND VGND VPWR VPWR net57 sky130_fd_sc_hd__buf_1
X_3460_ _1681_ VGND VGND VPWR VPWR _0482_ sky130_fd_sc_hd__clkbuf_1
X_3391_ net414 _1120_ _1636_ VGND VGND VPWR VPWR _1645_ sky130_fd_sc_hd__mux2_1
X_2411_ _1044_ net69 _1045_ VGND VGND VPWR VPWR _1046_ sky130_fd_sc_hd__mux2_1
X_2342_ _0992_ net52 _0978_ VGND VGND VPWR VPWR _0993_ sky130_fd_sc_hd__mux2_1
XFILLER_0_42_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4012_ clknet_leaf_8_clk _0052_ VGND VGND VPWR VPWR instance_2.data\[2\]\[52\] sky130_fd_sc_hd__dfxtp_1
X_2273_ _0939_ VGND VGND VPWR VPWR _0037_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_90_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_63_798 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3727_ _1821_ VGND VGND VPWR VPWR _0609_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_15_244 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1988_ _0721_ VGND VGND VPWR VPWR _0744_ sky130_fd_sc_hd__clkbuf_4
X_3658_ _1785_ VGND VGND VPWR VPWR _0576_ sky130_fd_sc_hd__clkbuf_1
X_2609_ net39 _1198_ _1199_ VGND VGND VPWR VPWR _1200_ sky130_fd_sc_hd__mux2_1
X_3589_ _0947_ net831 _1748_ VGND VGND VPWR VPWR _1749_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_54_710 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_78_472 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_26_445 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_65_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_53_328 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_80_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_34_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_21_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_88_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_88_269 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2960_ _0914_ net622 _1417_ VGND VGND VPWR VPWR _1418_ sky130_fd_sc_hd__mux2_1
X_2891_ _1380_ VGND VGND VPWR VPWR _0214_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_56_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_71_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4630_ clknet_leaf_52_clk _0670_ VGND VGND VPWR VPWR instance_2.data\[3\]\[22\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_60_768 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4561_ clknet_leaf_41_clk _0601_ VGND VGND VPWR VPWR instance_1.data\[0\]\[25\] sky130_fd_sc_hd__dfxtp_1
X_3512_ _1708_ VGND VGND VPWR VPWR _0507_ sky130_fd_sc_hd__clkbuf_1
Xhold616 instance_1.data\[0\]\[63\] VGND VGND VPWR VPWR net766 sky130_fd_sc_hd__dlygate4sd3_1
Xhold627 instance_1.data\[3\]\[61\] VGND VGND VPWR VPWR net777 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_40_545 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4492_ clknet_leaf_37_clk _0532_ VGND VGND VPWR VPWR instance_2.rdata\[28\] sky130_fd_sc_hd__dfxtp_1
Xhold605 instance_2.data\[0\]\[47\] VGND VGND VPWR VPWR net755 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_69_33 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3443_ _1672_ VGND VGND VPWR VPWR _0474_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_12_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xhold638 instance_2.data\[0\]\[24\] VGND VGND VPWR VPWR net788 sky130_fd_sc_hd__dlygate4sd3_1
Xhold649 instance_1.data\[2\]\[70\] VGND VGND VPWR VPWR net799 sky130_fd_sc_hd__dlygate4sd3_1
X_3374_ _1624_ VGND VGND VPWR VPWR _1636_ sky130_fd_sc_hd__buf_4
X_2325_ net759 _0979_ _0949_ VGND VGND VPWR VPWR _0980_ sky130_fd_sc_hd__mux2_1
X_2256_ _0926_ VGND VGND VPWR VPWR _0033_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_68_846 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_79_236 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_19_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2187_ _0872_ net13 _0842_ VGND VGND VPWR VPWR _0873_ sky130_fd_sc_hd__mux2_1
XFILLER_0_75_420 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_23_415 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_90_401 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_230 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_62_114 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_90_445 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_90_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_31_492 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_31_534 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_70_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_89_1048 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_39_570 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_26_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_30_38 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_34_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_22_545 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xhold2 instance_2.data\[1\]\[18\] VGND VGND VPWR VPWR net152 sky130_fd_sc_hd__dlygate4sd3_1
X_2110_ net157 _0807_ _0813_ VGND VGND VPWR VPWR _0814_ sky130_fd_sc_hd__mux2_1
X_3090_ _1486_ VGND VGND VPWR VPWR _0307_ sky130_fd_sc_hd__clkbuf_1
X_2041_ instance_1.rdata\[45\] instance_2.rdata\[45\] _0766_ VGND VGND VPWR VPWR _0772_
+ sky130_fd_sc_hd__mux2_1
XFILLER_0_55_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_65_816 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3992_ clknet_leaf_35_clk _0032_ VGND VGND VPWR VPWR instance_2.data\[2\]\[32\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_73_893 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2943_ _0887_ net850 _1406_ VGND VGND VPWR VPWR _1409_ sky130_fd_sc_hd__mux2_1
XFILLER_0_72_412 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_17_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_44_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2874_ net554 _1023_ _1369_ VGND VGND VPWR VPWR _1372_ sky130_fd_sc_hd__mux2_1
XFILLER_0_4_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4613_ clknet_leaf_55_clk _0653_ VGND VGND VPWR VPWR instance_2.data\[3\]\[5\] sky130_fd_sc_hd__dfxtp_1
X_4544_ clknet_leaf_56_clk _0584_ VGND VGND VPWR VPWR instance_1.data\[0\]\[8\] sky130_fd_sc_hd__dfxtp_1
Xhold402 instance_2.data\[2\]\[62\] VGND VGND VPWR VPWR net552 sky130_fd_sc_hd__dlygate4sd3_1
Xhold413 instance_1.rdata\[15\] VGND VGND VPWR VPWR net563 sky130_fd_sc_hd__dlygate4sd3_1
Xhold424 instance_1.data\[3\]\[69\] VGND VGND VPWR VPWR net574 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_52_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xhold435 instance_2.data\[2\]\[55\] VGND VGND VPWR VPWR net585 sky130_fd_sc_hd__dlygate4sd3_1
Xhold446 instance_1.data\[1\]\[47\] VGND VGND VPWR VPWR net596 sky130_fd_sc_hd__dlygate4sd3_1
X_4475_ clknet_leaf_48_clk _0515_ VGND VGND VPWR VPWR instance_2.rdata\[11\] sky130_fd_sc_hd__dfxtp_1
Xhold468 instance_1.data\[0\]\[17\] VGND VGND VPWR VPWR net618 sky130_fd_sc_hd__dlygate4sd3_1
Xhold457 instance_1.data\[1\]\[22\] VGND VGND VPWR VPWR net607 sky130_fd_sc_hd__dlygate4sd3_1
X_3426_ _1663_ VGND VGND VPWR VPWR _0466_ sky130_fd_sc_hd__clkbuf_1
Xhold479 instance_1.data\[3\]\[52\] VGND VGND VPWR VPWR net629 sky130_fd_sc_hd__dlygate4sd3_1
X_3357_ _1627_ VGND VGND VPWR VPWR _0433_ sky130_fd_sc_hd__clkbuf_1
X_2308_ _0966_ VGND VGND VPWR VPWR _0045_ sky130_fd_sc_hd__clkbuf_1
X_3288_ net268 _1198_ _1589_ VGND VGND VPWR VPWR _1591_ sky130_fd_sc_hd__mux2_1
X_2239_ instance_2.data\[0\]\[30\] instance_2.data\[1\]\[30\] instance_2.data\[2\]\[30\]
+ instance_2.data\[3\]\[30\] _0889_ _0902_ VGND VGND VPWR VPWR _0913_ sky130_fd_sc_hd__mux4_1
XTAP_TAPCELL_ROW_0_187 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_36_540 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_198 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_0_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_90_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_8_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_8_276 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_25_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_86_526 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_41_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_66_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_70_863 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_42_598 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_14_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2590_ net34 _1184_ _1165_ VGND VGND VPWR VPWR _1185_ sky130_fd_sc_hd__mux2_1
XFILLER_0_1_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_22_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_5_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4260_ clknet_leaf_45_clk _0300_ VGND VGND VPWR VPWR instance_1.data\[3\]\[12\] sky130_fd_sc_hd__dfxtp_1
X_3211_ _1550_ VGND VGND VPWR VPWR _0364_ sky130_fd_sc_hd__clkbuf_1
X_4191_ clknet_leaf_50_clk _0231_ VGND VGND VPWR VPWR instance_2.data\[0\]\[15\] sky130_fd_sc_hd__dfxtp_1
X_3142_ net283 _1209_ _1509_ VGND VGND VPWR VPWR _1514_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_78_941 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_82_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3073_ net566 _1098_ _1476_ VGND VGND VPWR VPWR _1478_ sky130_fd_sc_hd__mux2_1
XFILLER_0_82_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2024_ instance_1.rdata\[37\] instance_2.rdata\[37\] _0755_ VGND VGND VPWR VPWR _0763_
+ sky130_fd_sc_hd__mux2_1
XFILLER_0_89_386 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_33_510 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_92_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3975_ clknet_leaf_50_clk _0015_ VGND VGND VPWR VPWR instance_2.data\[2\]\[15\] sky130_fd_sc_hd__dfxtp_1
X_2926_ _0860_ net841 _1395_ VGND VGND VPWR VPWR _1400_ sky130_fd_sc_hd__mux2_1
XFILLER_0_9_369 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_72_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2857_ net362 _0996_ _1358_ VGND VGND VPWR VPWR _1363_ sky130_fd_sc_hd__mux2_1
XFILLER_0_86_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_60_415 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_60_448 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_13_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xhold210 instance_2.data\[3\]\[2\] VGND VGND VPWR VPWR net360 sky130_fd_sc_hd__dlygate4sd3_1
X_2788_ net660 _0884_ _1325_ VGND VGND VPWR VPWR _1327_ sky130_fd_sc_hd__mux2_1
Xhold232 instance_1.rdata\[47\] VGND VGND VPWR VPWR net382 sky130_fd_sc_hd__dlygate4sd3_1
Xhold221 instance_2.data\[3\]\[12\] VGND VGND VPWR VPWR net371 sky130_fd_sc_hd__dlygate4sd3_1
Xhold243 instance_2.data\[2\]\[4\] VGND VGND VPWR VPWR net393 sky130_fd_sc_hd__dlygate4sd3_1
X_4527_ clknet_leaf_3_clk _0567_ VGND VGND VPWR VPWR instance_2.rdata\[63\] sky130_fd_sc_hd__dfxtp_1
Xhold254 instance_1.data\[2\]\[53\] VGND VGND VPWR VPWR net404 sky130_fd_sc_hd__dlygate4sd3_1
Xhold276 instance_2.data\[3\]\[3\] VGND VGND VPWR VPWR net426 sky130_fd_sc_hd__dlygate4sd3_1
Xhold265 instance_2.data\[1\]\[16\] VGND VGND VPWR VPWR net415 sky130_fd_sc_hd__dlygate4sd3_1
Xhold287 instance_1.data\[3\]\[17\] VGND VGND VPWR VPWR net437 sky130_fd_sc_hd__dlygate4sd3_1
X_4458_ clknet_leaf_0_clk _0498_ VGND VGND VPWR VPWR instance_1.data\[2\]\[66\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_40_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xhold298 instance_1.data\[3\]\[36\] VGND VGND VPWR VPWR net448 sky130_fd_sc_hd__dlygate4sd3_1
X_3409_ _1654_ VGND VGND VPWR VPWR _0458_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_5_246 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4389_ clknet_leaf_5_clk _0429_ VGND VGND VPWR VPWR instance_1.rdata\[69\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_86_1018 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_68_515 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_84_999 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_83_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_36_445 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_51_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_36_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_75_911 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_47_646 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_52_14 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_74_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3760_ _1838_ VGND VGND VPWR VPWR _0625_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_6_328 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2711_ _1278_ VGND VGND VPWR VPWR _0136_ sky130_fd_sc_hd__clkbuf_1
X_3691_ _1802_ VGND VGND VPWR VPWR _0592_ sky130_fd_sc_hd__clkbuf_1
X_2642_ instance_1.data\[0\]\[49\] instance_1.data\[1\]\[49\] instance_1.data\[2\]\[49\]
+ instance_1.data\[3\]\[49\] _1211_ _1224_ VGND VGND VPWR VPWR _1225_ sky130_fd_sc_hd__mux4_1
X_2573_ net30 _1171_ _1165_ VGND VGND VPWR VPWR _1172_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_10_292 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_2_545 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4312_ clknet_leaf_1_clk _0352_ VGND VGND VPWR VPWR instance_1.data\[3\]\[64\] sky130_fd_sc_hd__dfxtp_1
X_4243_ clknet_leaf_5_clk _0283_ VGND VGND VPWR VPWR instance_2.data\[0\]\[67\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_77_99 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4174_ clknet_leaf_6_clk _0214_ VGND VGND VPWR VPWR instance_2.data\[1\]\[70\] sky130_fd_sc_hd__dfxtp_1
X_3125_ net448 _1182_ _1498_ VGND VGND VPWR VPWR _1505_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_2_216 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3056_ net581 _1070_ _1465_ VGND VGND VPWR VPWR _1469_ sky130_fd_sc_hd__mux2_1
XFILLER_0_89_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2007_ instance_1.rdata\[29\] instance_2.rdata\[29\] _0744_ VGND VGND VPWR VPWR _0754_
+ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_18_370 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_81_969 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_45_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3958_ net291 _1052_ _1864_ VGND VGND VPWR VPWR _1943_ sky130_fd_sc_hd__mux2_1
X_3889_ net172 _0941_ _1898_ VGND VGND VPWR VPWR _1907_ sky130_fd_sc_hd__mux2_1
X_2909_ _0832_ net603 _1384_ VGND VGND VPWR VPWR _1391_ sky130_fd_sc_hd__mux2_1
XFILLER_0_13_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_92_1077 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_44_616 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_36_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_52_693 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_91_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_2_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_63_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_59_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_47_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_59_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3812_ net430 _0816_ _1865_ VGND VGND VPWR VPWR _1867_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_15_340 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3743_ net223 _1200_ _1828_ VGND VGND VPWR VPWR _1830_ sky130_fd_sc_hd__mux2_1
XFILLER_0_12_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3674_ _1793_ VGND VGND VPWR VPWR _0584_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_42_234 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2625_ instance_1.data\[0\]\[45\] instance_1.data\[1\]\[45\] instance_1.data\[2\]\[45\]
+ instance_1.data\[3\]\[45\] _1211_ _1190_ VGND VGND VPWR VPWR _1212_ sky130_fd_sc_hd__mux4_1
Xoutput101 net101 VGND VGND VPWR VPWR rdata[31] sky130_fd_sc_hd__clkbuf_4
Xoutput112 net112 VGND VGND VPWR VPWR rdata[41] sky130_fd_sc_hd__clkbuf_4
Xoutput123 net123 VGND VGND VPWR VPWR rdata[51] sky130_fd_sc_hd__clkbuf_4
XFILLER_0_88_65 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput134 net134 VGND VGND VPWR VPWR rdata[61] sky130_fd_sc_hd__clkbuf_4
XFILLER_0_10_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xoutput145 net145 VGND VGND VPWR VPWR rdata[71] sky130_fd_sc_hd__clkbuf_4
X_2556_ net160 _1158_ _1128_ VGND VGND VPWR VPWR _1159_ sky130_fd_sc_hd__mux2_1
X_2487_ _1105_ VGND VGND VPWR VPWR _0085_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_10_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_49_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4226_ clknet_leaf_21_clk _0266_ VGND VGND VPWR VPWR instance_2.data\[0\]\[50\] sky130_fd_sc_hd__dfxtp_1
X_4157_ clknet_leaf_12_clk _0197_ VGND VGND VPWR VPWR instance_2.data\[1\]\[53\] sky130_fd_sc_hd__dfxtp_1
X_3108_ net251 _1154_ _1487_ VGND VGND VPWR VPWR _1496_ sky130_fd_sc_hd__mux2_1
X_4088_ clknet_leaf_15_clk _0128_ VGND VGND VPWR VPWR instance_1.data\[1\]\[56\] sky130_fd_sc_hd__dfxtp_1
X_3039_ _1042_ net756 _1450_ VGND VGND VPWR VPWR _1459_ sky130_fd_sc_hd__mux2_1
XFILLER_0_92_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_21_398 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_21_418 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_33_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_17_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_88_429 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_88_418 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_57_741 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_29_476 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_29_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_68_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_12_310 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_71_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xinput36 wdata[39] VGND VGND VPWR VPWR net36 sky130_fd_sc_hd__buf_1
Xinput14 wdata[19] VGND VGND VPWR VPWR net14 sky130_fd_sc_hd__buf_1
Xinput25 wdata[29] VGND VGND VPWR VPWR net25 sky130_fd_sc_hd__buf_1
Xinput47 wdata[49] VGND VGND VPWR VPWR net47 sky130_fd_sc_hd__buf_1
Xinput69 wdata[69] VGND VGND VPWR VPWR net69 sky130_fd_sc_hd__buf_1
Xinput58 wdata[59] VGND VGND VPWR VPWR net58 sky130_fd_sc_hd__buf_1
XFILLER_0_24_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2410_ _0720_ VGND VGND VPWR VPWR _1045_ sky130_fd_sc_hd__buf_4
X_3390_ _1644_ VGND VGND VPWR VPWR _0449_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_58_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2341_ instance_2.data\[0\]\[53\] instance_2.data\[1\]\[53\] instance_2.data\[2\]\[53\]
+ instance_2.data\[3\]\[53\] _0991_ _0970_ VGND VGND VPWR VPWR _0992_ sky130_fd_sc_hd__mux4_1
X_2272_ net177 _0938_ _0915_ VGND VGND VPWR VPWR _0939_ sky130_fd_sc_hd__mux2_1
X_4011_ clknet_leaf_8_clk _0051_ VGND VGND VPWR VPWR instance_2.data\[2\]\[51\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_90_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_59_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_28_551 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_63_799 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1987_ _0743_ VGND VGND VPWR VPWR net87 sky130_fd_sc_hd__buf_1
XFILLER_0_62_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3726_ net519 _1172_ _1817_ VGND VGND VPWR VPWR _1821_ sky130_fd_sc_hd__mux2_1
X_3657_ net200 _1056_ _1784_ VGND VGND VPWR VPWR _1785_ sky130_fd_sc_hd__mux2_1
XFILLER_0_70_384 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2608_ _1045_ VGND VGND VPWR VPWR _1199_ sky130_fd_sc_hd__buf_4
XFILLER_0_30_259 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3588_ _1300_ VGND VGND VPWR VPWR _1748_ sky130_fd_sc_hd__buf_4
X_2539_ net515 _1145_ _1128_ VGND VGND VPWR VPWR _1146_ sky130_fd_sc_hd__mux2_1
X_4209_ clknet_leaf_32_clk _0249_ VGND VGND VPWR VPWR instance_2.data\[0\]\[33\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_54_711 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_26_446 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_19_551 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_28_38 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_84_443 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2890_ net164 _1049_ _1302_ VGND VGND VPWR VPWR _1380_ sky130_fd_sc_hd__mux2_1
XPHY_EDGE_ROW_7_Left_100 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_60_769 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4560_ clknet_leaf_41_clk _0600_ VGND VGND VPWR VPWR instance_1.data\[0\]\[24\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_8_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3511_ _0822_ net769 _1704_ VGND VGND VPWR VPWR _1708_ sky130_fd_sc_hd__mux2_1
X_4491_ clknet_leaf_37_clk _0531_ VGND VGND VPWR VPWR instance_2.rdata\[27\] sky130_fd_sc_hd__dfxtp_1
Xhold606 instance_2.data\[0\]\[68\] VGND VGND VPWR VPWR net756 sky130_fd_sc_hd__dlygate4sd3_1
Xhold617 instance_2.data\[1\]\[46\] VGND VGND VPWR VPWR net767 sky130_fd_sc_hd__dlygate4sd3_1
X_3442_ net483 _1203_ _1669_ VGND VGND VPWR VPWR _1672_ sky130_fd_sc_hd__mux2_1
Xhold639 instance_2.data\[1\]\[20\] VGND VGND VPWR VPWR net789 sky130_fd_sc_hd__dlygate4sd3_1
Xhold628 instance_1.data\[2\]\[62\] VGND VGND VPWR VPWR net778 sky130_fd_sc_hd__dlygate4sd3_1
X_3373_ _1635_ VGND VGND VPWR VPWR _0441_ sky130_fd_sc_hd__clkbuf_1
X_2324_ _0977_ net47 _0978_ VGND VGND VPWR VPWR _0979_ sky130_fd_sc_hd__mux2_1
X_2255_ net287 _0925_ _0915_ VGND VGND VPWR VPWR _0926_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_68_847 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2186_ instance_2.data\[0\]\[18\] instance_2.data\[1\]\[18\] instance_2.data\[2\]\[18\]
+ instance_2.data\[3\]\[18\] _0855_ _0868_ VGND VGND VPWR VPWR _0872_ sky130_fd_sc_hd__mux4_1
XFILLER_0_87_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_23_416 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_90_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_90_457 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_7_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_31_493 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3709_ net638 _1145_ _1806_ VGND VGND VPWR VPWR _1812_ sky130_fd_sc_hd__mux2_1
XFILLER_0_31_546 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_11_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_89_1049 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_39_571 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_85_207 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_14_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_66_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_81_424 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_89_Left_182 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold3 instance_2.data\[2\]\[38\] VGND VGND VPWR VPWR net153 sky130_fd_sc_hd__dlygate4sd3_1
X_2040_ _0771_ VGND VGND VPWR VPWR net115 sky130_fd_sc_hd__buf_1
XTAP_TAPCELL_ROW_65_817 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3991_ clknet_leaf_32_clk _0031_ VGND VGND VPWR VPWR instance_2.data\[2\]\[31\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_69_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_73_894 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_71_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2942_ _1408_ VGND VGND VPWR VPWR _0237_ sky130_fd_sc_hd__clkbuf_1
X_2873_ _1371_ VGND VGND VPWR VPWR _0205_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_44_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4612_ clknet_leaf_59_clk _0652_ VGND VGND VPWR VPWR instance_2.data\[3\]\[4\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_13_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4543_ clknet_leaf_57_clk _0583_ VGND VGND VPWR VPWR instance_1.data\[0\]\[7\] sky130_fd_sc_hd__dfxtp_1
Xhold436 instance_1.data\[0\]\[38\] VGND VGND VPWR VPWR net586 sky130_fd_sc_hd__dlygate4sd3_1
Xhold425 instance_1.data\[3\]\[40\] VGND VGND VPWR VPWR net575 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_4_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xhold403 instance_1.data\[3\]\[9\] VGND VGND VPWR VPWR net553 sky130_fd_sc_hd__dlygate4sd3_1
Xhold414 instance_2.rdata\[41\] VGND VGND VPWR VPWR net564 sky130_fd_sc_hd__dlygate4sd3_1
X_4474_ clknet_leaf_50_clk _0514_ VGND VGND VPWR VPWR instance_2.rdata\[10\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_0_440 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xhold469 instance_2.data\[1\]\[27\] VGND VGND VPWR VPWR net619 sky130_fd_sc_hd__dlygate4sd3_1
Xhold447 instance_2.data\[2\]\[52\] VGND VGND VPWR VPWR net597 sky130_fd_sc_hd__dlygate4sd3_1
Xhold458 instance_2.data\[2\]\[51\] VGND VGND VPWR VPWR net608 sky130_fd_sc_hd__dlygate4sd3_1
X_3425_ net633 _1175_ _1658_ VGND VGND VPWR VPWR _1663_ sky130_fd_sc_hd__mux2_1
X_3356_ net199 _1064_ _1625_ VGND VGND VPWR VPWR _1627_ sky130_fd_sc_hd__mux2_1
X_3287_ _1590_ VGND VGND VPWR VPWR _0400_ sky130_fd_sc_hd__clkbuf_1
X_2307_ net735 _0965_ _0949_ VGND VGND VPWR VPWR _0966_ sky130_fd_sc_hd__mux2_1
X_2238_ _0912_ VGND VGND VPWR VPWR _0029_ sky130_fd_sc_hd__clkbuf_1
X_2169_ instance_2.data\[0\]\[14\] instance_2.data\[1\]\[14\] instance_2.data\[2\]\[14\]
+ instance_2.data\[3\]\[14\] _0855_ _0834_ VGND VGND VPWR VPWR _0859_ sky130_fd_sc_hd__mux4_1
XTAP_TAPCELL_ROW_0_188 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_36_541 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_67_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_0_199 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_8_551 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_63_424 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_63_435 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_16_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_31_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_8_277 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_86_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_25_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_39_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_70_864 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_42_599 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_5_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4190_ clknet_leaf_48_clk _0230_ VGND VGND VPWR VPWR instance_2.data\[0\]\[14\] sky130_fd_sc_hd__dfxtp_1
X_3210_ net697 _1072_ _1545_ VGND VGND VPWR VPWR _1550_ sky130_fd_sc_hd__mux2_1
X_3141_ _1513_ VGND VGND VPWR VPWR _0331_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_78_942 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3072_ _1477_ VGND VGND VPWR VPWR _0298_ sky130_fd_sc_hd__clkbuf_1
X_2023_ _0762_ VGND VGND VPWR VPWR net106 sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_33_511 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3974_ clknet_leaf_48_clk _0014_ VGND VGND VPWR VPWR instance_2.data\[2\]\[14\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_9_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2925_ _1399_ VGND VGND VPWR VPWR _0229_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_45_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2856_ _1362_ VGND VGND VPWR VPWR _0197_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_72_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_31_82 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_60_438 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xhold200 instance_1.data\[1\]\[51\] VGND VGND VPWR VPWR net350 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_79_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold211 instance_1.rdata\[59\] VGND VGND VPWR VPWR net361 sky130_fd_sc_hd__dlygate4sd3_1
X_2787_ _1326_ VGND VGND VPWR VPWR _0164_ sky130_fd_sc_hd__clkbuf_1
Xhold222 instance_2.data\[2\]\[7\] VGND VGND VPWR VPWR net372 sky130_fd_sc_hd__dlygate4sd3_1
Xhold233 instance_1.data\[1\]\[69\] VGND VGND VPWR VPWR net383 sky130_fd_sc_hd__dlygate4sd3_1
X_4526_ clknet_leaf_10_clk _0566_ VGND VGND VPWR VPWR instance_2.rdata\[62\] sky130_fd_sc_hd__dfxtp_1
Xhold244 instance_2.data\[3\]\[60\] VGND VGND VPWR VPWR net394 sky130_fd_sc_hd__dlygate4sd3_1
Xhold266 instance_1.data\[0\]\[52\] VGND VGND VPWR VPWR net416 sky130_fd_sc_hd__dlygate4sd3_1
Xhold277 instance_1.data\[0\]\[59\] VGND VGND VPWR VPWR net427 sky130_fd_sc_hd__dlygate4sd3_1
X_4457_ clknet_leaf_3_clk _0497_ VGND VGND VPWR VPWR instance_1.data\[2\]\[65\] sky130_fd_sc_hd__dfxtp_1
Xhold255 instance_1.rdata\[66\] VGND VGND VPWR VPWR net405 sky130_fd_sc_hd__dlygate4sd3_1
Xhold299 instance_1.data\[0\]\[26\] VGND VGND VPWR VPWR net449 sky130_fd_sc_hd__dlygate4sd3_1
X_3408_ net580 _1148_ _1647_ VGND VGND VPWR VPWR _1654_ sky130_fd_sc_hd__mux2_1
Xhold288 instance_2.data\[1\]\[58\] VGND VGND VPWR VPWR net438 sky130_fd_sc_hd__dlygate4sd3_1
X_4388_ clknet_leaf_5_clk _0428_ VGND VGND VPWR VPWR instance_1.rdata\[68\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_5_247 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3339_ _1617_ VGND VGND VPWR VPWR _0425_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_86_1019 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_48_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_63_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_91_541 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_36_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_36_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_75_912 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_leaf_56_clk clknet_3_1__leaf_clk VGND VGND VPWR VPWR clknet_leaf_56_clk sky130_fd_sc_hd__clkbuf_8
XTAP_TAPCELL_ROW_47_647 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_59_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_27_424 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_6_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2710_ net791 _1277_ _1264_ VGND VGND VPWR VPWR _1278_ sky130_fd_sc_hd__mux2_1
X_3690_ net484 _1114_ _1795_ VGND VGND VPWR VPWR _1802_ sky130_fd_sc_hd__mux2_1
XFILLER_0_54_298 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2641_ _0803_ VGND VGND VPWR VPWR _1224_ sky130_fd_sc_hd__clkbuf_4
X_2572_ instance_1.data\[0\]\[33\] instance_1.data\[1\]\[33\] instance_1.data\[2\]\[33\]
+ instance_1.data\[3\]\[33\] _1143_ _1156_ VGND VGND VPWR VPWR _1171_ sky130_fd_sc_hd__mux4_1
XTAP_TAPCELL_ROW_10_293 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_22_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4311_ clknet_leaf_1_clk _0351_ VGND VGND VPWR VPWR instance_1.data\[3\]\[63\] sky130_fd_sc_hd__dfxtp_1
X_4242_ clknet_leaf_3_clk _0282_ VGND VGND VPWR VPWR instance_2.data\[0\]\[66\] sky130_fd_sc_hd__dfxtp_1
X_4173_ clknet_leaf_7_clk _0213_ VGND VGND VPWR VPWR instance_2.data\[1\]\[69\] sky130_fd_sc_hd__dfxtp_1
X_3124_ _1504_ VGND VGND VPWR VPWR _0323_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_2_217 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3055_ _1468_ VGND VGND VPWR VPWR _0290_ sky130_fd_sc_hd__clkbuf_1
Xclkbuf_leaf_47_clk clknet_3_5__leaf_clk VGND VGND VPWR VPWR clknet_leaf_47_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_0_26_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2006_ _0753_ VGND VGND VPWR VPWR net97 sky130_fd_sc_hd__buf_1
XTAP_TAPCELL_ROW_18_371 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_92_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_85_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3957_ _1942_ VGND VGND VPWR VPWR _0718_ sky130_fd_sc_hd__clkbuf_1
X_2908_ _1390_ VGND VGND VPWR VPWR _0221_ sky130_fd_sc_hd__clkbuf_1
X_3888_ _1906_ VGND VGND VPWR VPWR _0685_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_33_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2839_ _1353_ VGND VGND VPWR VPWR _0189_ sky130_fd_sc_hd__clkbuf_1
X_4509_ clknet_leaf_19_clk _0549_ VGND VGND VPWR VPWR instance_2.rdata\[45\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_92_1078 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_leaf_38_clk clknet_3_4__leaf_clk VGND VGND VPWR VPWR clknet_leaf_38_clk sky130_fd_sc_hd__clkbuf_8
XTAP_TAPCELL_ROW_44_617 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_22_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_52_694 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_24_416 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_91_393 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_51_235 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_16_Left_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkbuf_leaf_29_clk clknet_3_7__leaf_clk VGND VGND VPWR VPWR clknet_leaf_29_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_0_63_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_86_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_59_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_86_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_59_357 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_15_341 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3811_ _1866_ VGND VGND VPWR VPWR _0648_ sky130_fd_sc_hd__clkbuf_1
XPHY_EDGE_ROW_25_Left_118 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_27_210 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_6_115 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_82_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3742_ _1829_ VGND VGND VPWR VPWR _0616_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_70_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3673_ net467 _1086_ _1784_ VGND VGND VPWR VPWR _1793_ sky130_fd_sc_hd__mux2_1
XFILLER_0_42_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2624_ _0801_ VGND VGND VPWR VPWR _1211_ sky130_fd_sc_hd__buf_4
Xoutput113 net113 VGND VGND VPWR VPWR rdata[42] sky130_fd_sc_hd__clkbuf_4
Xoutput124 net124 VGND VGND VPWR VPWR rdata[52] sky130_fd_sc_hd__clkbuf_4
XFILLER_0_88_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xoutput102 net102 VGND VGND VPWR VPWR rdata[32] sky130_fd_sc_hd__buf_2
Xoutput146 net146 VGND VGND VPWR VPWR rdata[7] sky130_fd_sc_hd__clkbuf_4
Xoutput135 net135 VGND VGND VPWR VPWR rdata[62] sky130_fd_sc_hd__clkbuf_4
X_2555_ net25 _1157_ _1131_ VGND VGND VPWR VPWR _1158_ sky130_fd_sc_hd__mux2_1
X_2486_ net397 _1104_ _1094_ VGND VGND VPWR VPWR _1105_ sky130_fd_sc_hd__mux2_1
XPHY_EDGE_ROW_34_Left_127 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4225_ clknet_leaf_6_clk _0265_ VGND VGND VPWR VPWR instance_2.data\[0\]\[49\] sky130_fd_sc_hd__dfxtp_1
X_4156_ clknet_leaf_8_clk _0196_ VGND VGND VPWR VPWR instance_2.data\[1\]\[52\] sky130_fd_sc_hd__dfxtp_1
X_3107_ _1495_ VGND VGND VPWR VPWR _0315_ sky130_fd_sc_hd__clkbuf_1
X_4087_ clknet_leaf_15_clk _0127_ VGND VGND VPWR VPWR instance_1.data\[1\]\[55\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_77_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3038_ _1458_ VGND VGND VPWR VPWR _0283_ sky130_fd_sc_hd__clkbuf_1
XPHY_EDGE_ROW_43_Left_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_92_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_18_221 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_61_522 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_21_399 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_33_268 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_52_Left_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_57_742 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_29_477 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_61_Left_154 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_12_311 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_37_541 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xinput37 wdata[3] VGND VGND VPWR VPWR net37 sky130_fd_sc_hd__buf_1
Xinput15 wdata[1] VGND VGND VPWR VPWR net15 sky130_fd_sc_hd__buf_1
Xinput26 wdata[2] VGND VGND VPWR VPWR net26 sky130_fd_sc_hd__buf_1
XFILLER_0_24_224 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_52_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_12_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xinput59 wdata[5] VGND VGND VPWR VPWR net59 sky130_fd_sc_hd__buf_1
Xinput48 wdata[4] VGND VGND VPWR VPWR net48 sky130_fd_sc_hd__buf_1
XPHY_EDGE_ROW_70_Left_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_58_14 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2340_ net1 VGND VGND VPWR VPWR _0991_ sky130_fd_sc_hd__buf_4
X_2271_ _0937_ net34 _0910_ VGND VGND VPWR VPWR _0938_ sky130_fd_sc_hd__mux2_1
X_4010_ clknet_leaf_7_clk _0050_ VGND VGND VPWR VPWR instance_2.data\[2\]\[50\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_87_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_7_435 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1986_ instance_1.rdata\[19\] instance_2.rdata\[19\] _0733_ VGND VGND VPWR VPWR _0743_
+ sky130_fd_sc_hd__mux2_1
XFILLER_0_43_522 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3725_ _1820_ VGND VGND VPWR VPWR _0608_ sky130_fd_sc_hd__clkbuf_1
Xclkbuf_leaf_9_clk clknet_3_2__leaf_clk VGND VGND VPWR VPWR clknet_leaf_9_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_0_70_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3656_ net150 VGND VGND VPWR VPWR _1784_ sky130_fd_sc_hd__buf_4
X_2607_ instance_1.data\[0\]\[41\] instance_1.data\[1\]\[41\] instance_1.data\[2\]\[41\]
+ instance_1.data\[3\]\[41\] _1177_ _1190_ VGND VGND VPWR VPWR _1198_ sky130_fd_sc_hd__mux4_1
XFILLER_0_61_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3587_ _1747_ VGND VGND VPWR VPWR _0543_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_11_463 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2538_ net21 _1144_ _1131_ VGND VGND VPWR VPWR _1145_ sky130_fd_sc_hd__mux2_1
X_2469_ _1091_ VGND VGND VPWR VPWR _0081_ sky130_fd_sc_hd__clkbuf_1
X_4208_ clknet_leaf_33_clk _0248_ VGND VGND VPWR VPWR instance_2.data\[0\]\[32\] sky130_fd_sc_hd__dfxtp_1
X_4139_ clknet_leaf_32_clk _0179_ VGND VGND VPWR VPWR instance_2.data\[1\]\[35\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_54_712 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_26_447 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_65_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_65_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_34_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_34_544 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_6_490 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_5_Left_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_88_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_84_400 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkbuf_3_4__f_clk clknet_0_clk VGND VGND VPWR VPWR clknet_3_4__leaf_clk sky130_fd_sc_hd__clkbuf_16
XFILLER_0_60_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_60_48 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3510_ _1707_ VGND VGND VPWR VPWR _0506_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_8_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold618 instance_2.rdata\[1\] VGND VGND VPWR VPWR net768 sky130_fd_sc_hd__dlygate4sd3_1
Xhold607 instance_2.data\[3\]\[13\] VGND VGND VPWR VPWR net757 sky130_fd_sc_hd__dlygate4sd3_1
X_4490_ clknet_leaf_39_clk _0530_ VGND VGND VPWR VPWR instance_2.rdata\[26\] sky130_fd_sc_hd__dfxtp_1
X_3441_ _1671_ VGND VGND VPWR VPWR _0473_ sky130_fd_sc_hd__clkbuf_1
Xhold629 instance_2.data\[3\]\[45\] VGND VGND VPWR VPWR net779 sky130_fd_sc_hd__dlygate4sd3_1
X_3372_ net582 _1090_ _1625_ VGND VGND VPWR VPWR _1635_ sky130_fd_sc_hd__mux2_1
X_2323_ _0720_ VGND VGND VPWR VPWR _0978_ sky130_fd_sc_hd__buf_4
X_2254_ _0924_ net30 _0910_ VGND VGND VPWR VPWR _0925_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_68_848 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_18_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2185_ _0871_ VGND VGND VPWR VPWR _0017_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_87_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_23_417 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_16_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_90_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1969_ _0734_ VGND VGND VPWR VPWR net78 sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_31_494 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_50_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3708_ _1811_ VGND VGND VPWR VPWR _0600_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_43_363 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3639_ _1029_ net632 _1770_ VGND VGND VPWR VPWR _1775_ sky130_fd_sc_hd__mux2_1
XFILLER_0_11_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_39_572 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_66_433 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold4 instance_1.data\[1\]\[16\] VGND VGND VPWR VPWR net154 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_89_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_65_818 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3990_ clknet_leaf_36_clk _0030_ VGND VGND VPWR VPWR instance_2.data\[2\]\[30\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_73_895 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2941_ _0884_ net861 _1406_ VGND VGND VPWR VPWR _1408_ sky130_fd_sc_hd__mux2_1
XFILLER_0_69_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4611_ clknet_leaf_60_clk _0651_ VGND VGND VPWR VPWR instance_2.data\[3\]\[3\] sky130_fd_sc_hd__dfxtp_1
X_2872_ net694 _1020_ _1369_ VGND VGND VPWR VPWR _1371_ sky130_fd_sc_hd__mux2_1
XFILLER_0_44_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_13_525 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4542_ clknet_leaf_58_clk _0582_ VGND VGND VPWR VPWR instance_1.data\[0\]\[6\] sky130_fd_sc_hd__dfxtp_1
Xhold426 instance_1.data\[2\]\[48\] VGND VGND VPWR VPWR net576 sky130_fd_sc_hd__dlygate4sd3_1
Xhold415 instance_1.data\[2\]\[8\] VGND VGND VPWR VPWR net565 sky130_fd_sc_hd__dlygate4sd3_1
X_4473_ clknet_leaf_50_clk _0513_ VGND VGND VPWR VPWR instance_2.rdata\[9\] sky130_fd_sc_hd__dfxtp_1
Xhold404 instance_2.data\[1\]\[62\] VGND VGND VPWR VPWR net554 sky130_fd_sc_hd__dlygate4sd3_1
Xhold437 instance_1.data\[3\]\[41\] VGND VGND VPWR VPWR net587 sky130_fd_sc_hd__dlygate4sd3_1
X_3424_ _1662_ VGND VGND VPWR VPWR _0465_ sky130_fd_sc_hd__clkbuf_1
Xhold459 instance_1.data\[0\]\[12\] VGND VGND VPWR VPWR net609 sky130_fd_sc_hd__dlygate4sd3_1
Xhold448 instance_2.data\[0\]\[54\] VGND VGND VPWR VPWR net598 sky130_fd_sc_hd__dlygate4sd3_1
X_3355_ _1626_ VGND VGND VPWR VPWR _0432_ sky130_fd_sc_hd__clkbuf_1
X_3286_ net369 _1194_ _1589_ VGND VGND VPWR VPWR _1590_ sky130_fd_sc_hd__mux2_1
X_2306_ _0964_ net43 _0944_ VGND VGND VPWR VPWR _0965_ sky130_fd_sc_hd__mux2_1
X_2237_ net513 _0911_ _0881_ VGND VGND VPWR VPWR _0912_ sky130_fd_sc_hd__mux2_1
X_2168_ _0858_ VGND VGND VPWR VPWR _0013_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_36_542 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2099_ net2 VGND VGND VPWR VPWR _0803_ sky130_fd_sc_hd__buf_4
XTAP_TAPCELL_ROW_0_189 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_48_433 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_61_80 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_17_Right_17 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_8_278 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_26_Right_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_39_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_54_403 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_26_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_35_Right_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_70_865 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_81_233 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_44_Right_44 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3140_ net186 _1206_ _1509_ VGND VGND VPWR VPWR _1513_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_78_943 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3071_ net245 _1093_ _1476_ VGND VGND VPWR VPWR _1477_ sky130_fd_sc_hd__mux2_1
X_2022_ instance_1.rdata\[36\] instance_2.rdata\[36\] _0755_ VGND VGND VPWR VPWR _0762_
+ sky130_fd_sc_hd__mux2_1
XFILLER_0_15_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_33_512 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3973_ clknet_leaf_48_clk _0013_ VGND VGND VPWR VPWR instance_2.data\[2\]\[13\] sky130_fd_sc_hd__dfxtp_1
XPHY_EDGE_ROW_53_Right_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2924_ _0857_ net455 _1395_ VGND VGND VPWR VPWR _1399_ sky130_fd_sc_hd__mux2_1
X_2855_ net176 _0993_ _1358_ VGND VGND VPWR VPWR _1362_ sky130_fd_sc_hd__mux2_1
XFILLER_0_31_72 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_31_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold201 instance_2.data\[1\]\[0\] VGND VGND VPWR VPWR net351 sky130_fd_sc_hd__dlygate4sd3_1
X_2786_ net789 _0880_ _1325_ VGND VGND VPWR VPWR _1326_ sky130_fd_sc_hd__mux2_1
X_4525_ clknet_leaf_2_clk _0565_ VGND VGND VPWR VPWR instance_2.rdata\[61\] sky130_fd_sc_hd__dfxtp_1
Xhold234 instance_2.data\[1\]\[6\] VGND VGND VPWR VPWR net384 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_13_366 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold223 instance_1.rdata\[64\] VGND VGND VPWR VPWR net373 sky130_fd_sc_hd__dlygate4sd3_1
Xhold212 instance_2.data\[1\]\[54\] VGND VGND VPWR VPWR net362 sky130_fd_sc_hd__dlygate4sd3_1
Xhold278 instance_1.data\[0\]\[45\] VGND VGND VPWR VPWR net428 sky130_fd_sc_hd__dlygate4sd3_1
Xhold245 instance_2.data\[1\]\[14\] VGND VGND VPWR VPWR net395 sky130_fd_sc_hd__dlygate4sd3_1
X_4456_ clknet_leaf_1_clk _0496_ VGND VGND VPWR VPWR instance_1.data\[2\]\[64\] sky130_fd_sc_hd__dfxtp_1
Xhold267 instance_1.data\[3\]\[70\] VGND VGND VPWR VPWR net417 sky130_fd_sc_hd__dlygate4sd3_1
Xhold256 instance_1.rdata\[28\] VGND VGND VPWR VPWR net406 sky130_fd_sc_hd__dlygate4sd3_1
XPHY_EDGE_ROW_62_Right_62 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold289 instance_1.rdata\[49\] VGND VGND VPWR VPWR net439 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_0_260 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4387_ clknet_leaf_5_clk _0427_ VGND VGND VPWR VPWR instance_1.rdata\[67\] sky130_fd_sc_hd__dfxtp_1
X_3407_ _1653_ VGND VGND VPWR VPWR _0457_ sky130_fd_sc_hd__clkbuf_1
X_3338_ net315 _1279_ _1611_ VGND VGND VPWR VPWR _1617_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_5_248 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3269_ net525 _1168_ _1578_ VGND VGND VPWR VPWR _1581_ sky130_fd_sc_hd__mux2_1
XPHY_EDGE_ROW_71_Right_71 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_80_Right_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_75_913 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_47_648 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_83_990 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_54_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2640_ _1223_ VGND VGND VPWR VPWR _0120_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_10_294 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_22_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2571_ _1170_ VGND VGND VPWR VPWR _0104_ sky130_fd_sc_hd__clkbuf_1
X_4310_ clknet_leaf_1_clk _0350_ VGND VGND VPWR VPWR instance_1.data\[3\]\[62\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_77_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4241_ clknet_leaf_9_clk _0281_ VGND VGND VPWR VPWR instance_2.data\[0\]\[65\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_58_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4172_ clknet_leaf_7_clk _0212_ VGND VGND VPWR VPWR instance_2.data\[1\]\[68\] sky130_fd_sc_hd__dfxtp_1
X_3123_ net834 _1179_ _1498_ VGND VGND VPWR VPWR _1504_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_2_218 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3054_ net676 _1067_ _1465_ VGND VGND VPWR VPWR _1468_ sky130_fd_sc_hd__mux2_1
X_2005_ instance_1.rdata\[28\] instance_2.rdata\[28\] _0744_ VGND VGND VPWR VPWR _0753_
+ sky130_fd_sc_hd__mux2_1
XFILLER_0_9_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_18_372 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_92_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3956_ net173 _1049_ _1864_ VGND VGND VPWR VPWR _1942_ sky130_fd_sc_hd__mux2_1
XFILLER_0_18_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2907_ _0829_ net458 _1384_ VGND VGND VPWR VPWR _1390_ sky130_fd_sc_hd__mux2_1
XFILLER_0_91_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3887_ net304 _0938_ _1898_ VGND VGND VPWR VPWR _1906_ sky130_fd_sc_hd__mux2_1
XFILLER_0_5_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_33_439 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2838_ net492 _0965_ _1347_ VGND VGND VPWR VPWR _1353_ sky130_fd_sc_hd__mux2_1
X_2769_ net512 _0853_ _1314_ VGND VGND VPWR VPWR _1317_ sky130_fd_sc_hd__mux2_1
X_4508_ clknet_leaf_25_clk _0548_ VGND VGND VPWR VPWR instance_2.rdata\[44\] sky130_fd_sc_hd__dfxtp_1
X_4439_ clknet_leaf_18_clk _0479_ VGND VGND VPWR VPWR instance_1.data\[2\]\[47\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_92_1079 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_44_618 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_80_960 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_52_695 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_51_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_2_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_63_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_86_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_59_369 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_15_342 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3810_ net494 _0807_ _1865_ VGND VGND VPWR VPWR _1866_ sky130_fd_sc_hd__mux2_1
X_3741_ net236 _1195_ _1828_ VGND VGND VPWR VPWR _1829_ sky130_fd_sc_hd__mux2_1
XFILLER_0_6_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_67_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_12_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_127 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3672_ _1792_ VGND VGND VPWR VPWR _0583_ sky130_fd_sc_hd__clkbuf_1
X_2623_ _1210_ VGND VGND VPWR VPWR _0116_ sky130_fd_sc_hd__clkbuf_1
Xoutput114 net114 VGND VGND VPWR VPWR rdata[43] sky130_fd_sc_hd__clkbuf_4
X_2554_ instance_1.data\[0\]\[29\] instance_1.data\[1\]\[29\] instance_1.data\[2\]\[29\]
+ instance_1.data\[3\]\[29\] _1143_ _1156_ VGND VGND VPWR VPWR _1157_ sky130_fd_sc_hd__mux4_1
Xoutput125 net125 VGND VGND VPWR VPWR rdata[53] sky130_fd_sc_hd__clkbuf_4
Xoutput103 net103 VGND VGND VPWR VPWR rdata[33] sky130_fd_sc_hd__buf_2
Xoutput147 net147 VGND VGND VPWR VPWR rdata[8] sky130_fd_sc_hd__clkbuf_4
Xoutput136 net136 VGND VGND VPWR VPWR rdata[63] sky130_fd_sc_hd__clkbuf_4
XFILLER_0_50_280 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2485_ net8 _1103_ _1097_ VGND VGND VPWR VPWR _1104_ sky130_fd_sc_hd__mux2_1
X_4224_ clknet_leaf_21_clk _0264_ VGND VGND VPWR VPWR instance_2.data\[0\]\[48\] sky130_fd_sc_hd__dfxtp_1
X_4155_ clknet_leaf_8_clk _0195_ VGND VGND VPWR VPWR instance_2.data\[1\]\[51\] sky130_fd_sc_hd__dfxtp_1
X_3106_ net298 _1151_ _1487_ VGND VGND VPWR VPWR _1495_ sky130_fd_sc_hd__mux2_1
X_4086_ clknet_leaf_15_clk _0126_ VGND VGND VPWR VPWR instance_1.data\[1\]\[54\] sky130_fd_sc_hd__dfxtp_1
X_3037_ _1039_ net833 _1450_ VGND VGND VPWR VPWR _1458_ sky130_fd_sc_hd__mux2_1
XFILLER_0_92_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_18_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_92_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3939_ _1933_ VGND VGND VPWR VPWR _0709_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_33_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_21_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_57_743 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_29_478 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_68_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_83_136 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_49_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_83_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_12_312 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xinput16 wdata[20] VGND VGND VPWR VPWR net16 sky130_fd_sc_hd__buf_1
XFILLER_0_52_545 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xinput27 wdata[30] VGND VGND VPWR VPWR net27 sky130_fd_sc_hd__buf_1
Xinput38 wdata[40] VGND VGND VPWR VPWR net38 sky130_fd_sc_hd__buf_1
Xinput49 wdata[50] VGND VGND VPWR VPWR net49 sky130_fd_sc_hd__buf_1
XFILLER_0_58_37 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_20_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_20_486 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2270_ instance_2.data\[0\]\[37\] instance_2.data\[1\]\[37\] instance_2.data\[2\]\[37\]
+ instance_2.data\[3\]\[37\] _0923_ _0936_ VGND VGND VPWR VPWR _0937_ sky130_fd_sc_hd__mux4_1
XFILLER_0_79_409 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1985_ _0742_ VGND VGND VPWR VPWR net86 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_62_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_43_534 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3724_ net347 _1169_ _1817_ VGND VGND VPWR VPWR _1820_ sky130_fd_sc_hd__mux2_1
X_3655_ _0808_ _0809_ _1058_ VGND VGND VPWR VPWR _1783_ sky130_fd_sc_hd__nor3_4
XFILLER_0_70_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2606_ _1197_ VGND VGND VPWR VPWR _0112_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_30_239 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3586_ _0943_ net655 _1737_ VGND VGND VPWR VPWR _1747_ sky130_fd_sc_hd__mux2_1
XFILLER_0_11_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2537_ instance_1.data\[0\]\[25\] instance_1.data\[1\]\[25\] instance_1.data\[2\]\[25\]
+ instance_1.data\[3\]\[25\] _1143_ _1122_ VGND VGND VPWR VPWR _1144_ sky130_fd_sc_hd__mux4_1
X_2468_ net278 _1090_ _1060_ VGND VGND VPWR VPWR _1091_ sky130_fd_sc_hd__mux2_1
XFILLER_0_54_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4207_ clknet_leaf_32_clk _0247_ VGND VGND VPWR VPWR instance_2.data\[0\]\[31\] sky130_fd_sc_hd__dfxtp_1
X_2399_ net507 _1036_ _1017_ VGND VGND VPWR VPWR _1037_ sky130_fd_sc_hd__mux2_1
X_4138_ clknet_leaf_32_clk _0178_ VGND VGND VPWR VPWR instance_2.data\[1\]\[34\] sky130_fd_sc_hd__dfxtp_1
X_4069_ clknet_leaf_30_clk _0109_ VGND VGND VPWR VPWR instance_1.data\[1\]\[37\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_54_713 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_78_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_26_448 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_38_317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_62_790 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_6_480 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_69_442 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_56_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_84_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_44_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_64_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xhold608 instance_2.data\[3\]\[21\] VGND VGND VPWR VPWR net758 sky130_fd_sc_hd__dlygate4sd3_1
X_3440_ net190 _1200_ _1669_ VGND VGND VPWR VPWR _1671_ sky130_fd_sc_hd__mux2_1
Xhold619 instance_2.rdata\[3\] VGND VGND VPWR VPWR net769 sky130_fd_sc_hd__dlygate4sd3_1
X_3371_ _1634_ VGND VGND VPWR VPWR _0440_ sky130_fd_sc_hd__clkbuf_1
X_2322_ instance_2.data\[0\]\[49\] instance_2.data\[1\]\[49\] instance_2.data\[2\]\[49\]
+ instance_2.data\[3\]\[49\] _0957_ _0970_ VGND VGND VPWR VPWR _0977_ sky130_fd_sc_hd__mux4_1
XFILLER_0_85_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2253_ instance_2.data\[0\]\[33\] instance_2.data\[1\]\[33\] instance_2.data\[2\]\[33\]
+ instance_2.data\[3\]\[33\] _0923_ _0902_ VGND VGND VPWR VPWR _0924_ sky130_fd_sc_hd__mux4_1
X_2184_ net376 _0870_ _0847_ VGND VGND VPWR VPWR _0871_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_68_849 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_34_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_23_418 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_62_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_16_545 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1968_ instance_1.rdata\[10\] instance_2.rdata\[10\] _0733_ VGND VGND VPWR VPWR _0734_
+ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_31_495 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3707_ net503 _1141_ _1806_ VGND VGND VPWR VPWR _1811_ sky130_fd_sc_hd__mux2_1
XFILLER_0_43_375 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3638_ _1774_ VGND VGND VPWR VPWR _0567_ sky130_fd_sc_hd__clkbuf_1
X_3569_ _1738_ VGND VGND VPWR VPWR _0534_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_59_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_39_573 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_61_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xhold5 instance_2.data\[2\]\[1\] VGND VGND VPWR VPWR net155 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_65_819 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_71_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_73_896 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2940_ _1407_ VGND VGND VPWR VPWR _0236_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_57_423 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_84_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_29_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2871_ _1370_ VGND VGND VPWR VPWR _0204_ sky130_fd_sc_hd__clkbuf_1
X_4610_ clknet_leaf_62_clk _0650_ VGND VGND VPWR VPWR instance_2.data\[3\]\[2\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_37_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_20_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4541_ clknet_leaf_55_clk _0581_ VGND VGND VPWR VPWR instance_1.data\[0\]\[5\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_40_312 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4472_ clknet_leaf_56_clk _0512_ VGND VGND VPWR VPWR instance_2.rdata\[8\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_13_537 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold416 instance_1.data\[3\]\[11\] VGND VGND VPWR VPWR net566 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_20_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xhold427 instance_1.data\[3\]\[19\] VGND VGND VPWR VPWR net577 sky130_fd_sc_hd__dlygate4sd3_1
Xhold405 instance_1.data\[1\]\[61\] VGND VGND VPWR VPWR net555 sky130_fd_sc_hd__dlygate4sd3_1
X_3423_ net239 _1172_ _1658_ VGND VGND VPWR VPWR _1662_ sky130_fd_sc_hd__mux2_1
Xhold449 instance_2.data\[1\]\[3\] VGND VGND VPWR VPWR net599 sky130_fd_sc_hd__dlygate4sd3_1
Xhold438 instance_1.data\[2\]\[66\] VGND VGND VPWR VPWR net588 sky130_fd_sc_hd__dlygate4sd3_1
X_3354_ net180 _1056_ _1625_ VGND VGND VPWR VPWR _1626_ sky130_fd_sc_hd__mux2_1
X_3285_ _1544_ VGND VGND VPWR VPWR _1589_ sky130_fd_sc_hd__clkbuf_4
X_2305_ instance_2.data\[0\]\[45\] instance_2.data\[1\]\[45\] instance_2.data\[2\]\[45\]
+ instance_2.data\[3\]\[45\] _0957_ _0936_ VGND VGND VPWR VPWR _0964_ sky130_fd_sc_hd__mux4_1
X_2236_ _0909_ net25 _0910_ VGND VGND VPWR VPWR _0911_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_88_1040 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_17_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2167_ net387 _0857_ _0847_ VGND VGND VPWR VPWR _0858_ sky130_fd_sc_hd__mux2_1
X_2098_ _0801_ VGND VGND VPWR VPWR _0802_ sky130_fd_sc_hd__buf_4
XTAP_TAPCELL_ROW_36_543 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_8_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_48_456 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_75_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_61_92 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_71_492 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_31_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_8_279 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_81_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_70_866 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_81_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_26_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_66_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_78_944 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3070_ _1464_ VGND VGND VPWR VPWR _1476_ sky130_fd_sc_hd__buf_4
XFILLER_0_89_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2021_ _0761_ VGND VGND VPWR VPWR net105 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_15_63 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_85_551 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3972_ clknet_leaf_49_clk _0012_ VGND VGND VPWR VPWR instance_2.data\[2\]\[12\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_33_513 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2923_ _1398_ VGND VGND VPWR VPWR _0228_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_31_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2854_ _1361_ VGND VGND VPWR VPWR _0196_ sky130_fd_sc_hd__clkbuf_1
X_2785_ _1302_ VGND VGND VPWR VPWR _1325_ sky130_fd_sc_hd__buf_4
XTAP_TAPCELL_ROW_41_590 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xhold202 instance_1.rdata\[36\] VGND VGND VPWR VPWR net352 sky130_fd_sc_hd__dlygate4sd3_1
X_4524_ clknet_leaf_2_clk _0564_ VGND VGND VPWR VPWR instance_2.rdata\[60\] sky130_fd_sc_hd__dfxtp_1
Xhold235 instance_1.data\[0\]\[43\] VGND VGND VPWR VPWR net385 sky130_fd_sc_hd__dlygate4sd3_1
Xhold213 instance_2.data\[2\]\[3\] VGND VGND VPWR VPWR net363 sky130_fd_sc_hd__dlygate4sd3_1
Xhold224 instance_2.data\[2\]\[39\] VGND VGND VPWR VPWR net374 sky130_fd_sc_hd__dlygate4sd3_1
Xhold257 instance_2.data\[3\]\[34\] VGND VGND VPWR VPWR net407 sky130_fd_sc_hd__dlygate4sd3_1
Xhold246 instance_1.data\[1\]\[33\] VGND VGND VPWR VPWR net396 sky130_fd_sc_hd__dlygate4sd3_1
X_4455_ clknet_leaf_1_clk _0495_ VGND VGND VPWR VPWR instance_1.data\[2\]\[63\] sky130_fd_sc_hd__dfxtp_1
Xhold268 instance_1.rdata\[23\] VGND VGND VPWR VPWR net418 sky130_fd_sc_hd__dlygate4sd3_1
Xhold279 instance_1.data\[3\]\[50\] VGND VGND VPWR VPWR net429 sky130_fd_sc_hd__dlygate4sd3_1
X_4386_ clknet_leaf_3_clk _0426_ VGND VGND VPWR VPWR instance_1.rdata\[66\] sky130_fd_sc_hd__dfxtp_1
X_3406_ net336 _1145_ _1647_ VGND VGND VPWR VPWR _1653_ sky130_fd_sc_hd__mux2_1
X_3337_ _1616_ VGND VGND VPWR VPWR _0424_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_5_249 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3268_ _1580_ VGND VGND VPWR VPWR _0391_ sky130_fd_sc_hd__clkbuf_1
X_3199_ _1543_ VGND VGND VPWR VPWR _0359_ sky130_fd_sc_hd__clkbuf_1
X_2219_ net433 _0897_ _0881_ VGND VGND VPWR VPWR _0898_ sky130_fd_sc_hd__mux2_1
XFILLER_0_48_264 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_16_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_51_407 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_6_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_75_914 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_86_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_47_649 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_83_991 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_22_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2570_ net615 _1169_ _1162_ VGND VGND VPWR VPWR _1170_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_10_295 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_50_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_77_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_22_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4240_ clknet_leaf_9_clk _0280_ VGND VGND VPWR VPWR instance_2.data\[0\]\[64\] sky130_fd_sc_hd__dfxtp_1
X_4171_ clknet_leaf_7_clk _0211_ VGND VGND VPWR VPWR instance_2.data\[1\]\[67\] sky130_fd_sc_hd__dfxtp_1
X_3122_ _1503_ VGND VGND VPWR VPWR _0322_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_2_219 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3053_ _1467_ VGND VGND VPWR VPWR _0289_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_85_1010 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2004_ _0752_ VGND VGND VPWR VPWR net96 sky130_fd_sc_hd__buf_1
XFILLER_0_92_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_18_373 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_73_521 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_9_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_18_404 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_42_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3955_ _1941_ VGND VGND VPWR VPWR _0717_ sky130_fd_sc_hd__clkbuf_1
X_2906_ _1389_ VGND VGND VPWR VPWR _0220_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_45_234 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3886_ _1905_ VGND VGND VPWR VPWR _0684_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_84_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2837_ _1352_ VGND VGND VPWR VPWR _0188_ sky130_fd_sc_hd__clkbuf_1
X_2768_ _1316_ VGND VGND VPWR VPWR _0155_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_13_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2699_ _1269_ VGND VGND VPWR VPWR _0133_ sky130_fd_sc_hd__clkbuf_1
X_4507_ clknet_leaf_25_clk _0547_ VGND VGND VPWR VPWR instance_2.rdata\[43\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_92_1069 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4438_ clknet_leaf_18_clk _0478_ VGND VGND VPWR VPWR instance_1.data\[2\]\[46\] sky130_fd_sc_hd__dfxtp_1
X_4369_ clknet_leaf_19_clk _0409_ VGND VGND VPWR VPWR instance_1.rdata\[49\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_6_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_44_619 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_83_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_80_961 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_52_696 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_8_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_51_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_32_495 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_59_304 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_15_343 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3740_ _1783_ VGND VGND VPWR VPWR _1828_ sky130_fd_sc_hd__buf_4
XFILLER_0_12_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_27_256 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3671_ net523 _1083_ _1784_ VGND VGND VPWR VPWR _1792_ sky130_fd_sc_hd__mux2_1
X_2622_ net444 _1209_ _1196_ VGND VGND VPWR VPWR _1210_ sky130_fd_sc_hd__mux2_1
Xoutput115 net115 VGND VGND VPWR VPWR rdata[44] sky130_fd_sc_hd__clkbuf_4
Xoutput104 net104 VGND VGND VPWR VPWR rdata[34] sky130_fd_sc_hd__clkbuf_4
X_2553_ _0803_ VGND VGND VPWR VPWR _1156_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_70_9 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput148 net148 VGND VGND VPWR VPWR rdata[9] sky130_fd_sc_hd__clkbuf_4
Xoutput137 net137 VGND VGND VPWR VPWR rdata[64] sky130_fd_sc_hd__clkbuf_4
Xoutput126 net126 VGND VGND VPWR VPWR rdata[54] sky130_fd_sc_hd__clkbuf_4
X_2484_ instance_1.data\[0\]\[13\] instance_1.data\[1\]\[13\] instance_1.data\[2\]\[13\]
+ instance_1.data\[3\]\[13\] _1075_ _1088_ VGND VGND VPWR VPWR _1103_ sky130_fd_sc_hd__mux4_1
X_4223_ clknet_leaf_21_clk _0263_ VGND VGND VPWR VPWR instance_2.data\[0\]\[47\] sky130_fd_sc_hd__dfxtp_1
X_4154_ clknet_leaf_20_clk _0194_ VGND VGND VPWR VPWR instance_2.data\[1\]\[50\] sky130_fd_sc_hd__dfxtp_1
X_4085_ clknet_leaf_15_clk _0125_ VGND VGND VPWR VPWR instance_1.data\[1\]\[53\] sky130_fd_sc_hd__dfxtp_1
X_3105_ _1494_ VGND VGND VPWR VPWR _0314_ sky130_fd_sc_hd__clkbuf_1
X_3036_ _1457_ VGND VGND VPWR VPWR _0282_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_92_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_18_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3938_ net337 _1020_ _1931_ VGND VGND VPWR VPWR _1933_ sky130_fd_sc_hd__mux2_1
X_3869_ _1896_ VGND VGND VPWR VPWR _0676_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_41_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_57_744 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_29_479 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_83_148 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_49_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_12_313 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_91_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xinput17 wdata[21] VGND VGND VPWR VPWR net17 sky130_fd_sc_hd__buf_1
Xinput28 wdata[31] VGND VGND VPWR VPWR net28 sky130_fd_sc_hd__clkbuf_1
Xinput39 wdata[41] VGND VGND VPWR VPWR net39 sky130_fd_sc_hd__buf_1
XFILLER_0_24_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_20_390 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_20_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_20_454 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_58_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_74_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_87_454 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_59_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_7_415 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_28_521 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1984_ instance_1.rdata\[18\] instance_2.rdata\[18\] _0733_ VGND VGND VPWR VPWR _0742_
+ sky130_fd_sc_hd__mux2_1
XFILLER_0_43_502 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3723_ _1819_ VGND VGND VPWR VPWR _0607_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_70_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3654_ _1782_ VGND VGND VPWR VPWR _0575_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_43_546 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2605_ net535 _1195_ _1196_ VGND VGND VPWR VPWR _1197_ sky130_fd_sc_hd__mux2_1
XFILLER_0_70_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3585_ _1746_ VGND VGND VPWR VPWR _0542_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_11_410 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_70_398 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2536_ _0801_ VGND VGND VPWR VPWR _1143_ sky130_fd_sc_hd__buf_4
XFILLER_0_2_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2467_ net75 _1089_ _1063_ VGND VGND VPWR VPWR _1090_ sky130_fd_sc_hd__mux2_1
X_4206_ clknet_leaf_36_clk _0246_ VGND VGND VPWR VPWR instance_2.data\[0\]\[30\] sky130_fd_sc_hd__dfxtp_1
X_2398_ _1035_ net66 _1012_ VGND VGND VPWR VPWR _1036_ sky130_fd_sc_hd__mux2_1
XFILLER_0_3_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4137_ clknet_leaf_32_clk _0177_ VGND VGND VPWR VPWR instance_2.data\[1\]\[33\] sky130_fd_sc_hd__dfxtp_1
X_4068_ clknet_leaf_30_clk _0108_ VGND VGND VPWR VPWR instance_1.data\[1\]\[36\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_78_421 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_54_714 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3019_ _1448_ VGND VGND VPWR VPWR _0274_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_26_449 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_38_329 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_19_521 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_80_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_62_791 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_46_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_8_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold609 instance_2.data\[2\]\[49\] VGND VGND VPWR VPWR net759 sky130_fd_sc_hd__dlygate4sd3_1
X_3370_ net565 _1086_ _1625_ VGND VGND VPWR VPWR _1634_ sky130_fd_sc_hd__mux2_1
XFILLER_0_20_262 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2321_ _0976_ VGND VGND VPWR VPWR _0048_ sky130_fd_sc_hd__clkbuf_1
X_2252_ net1 VGND VGND VPWR VPWR _0923_ sky130_fd_sc_hd__buf_4
XFILLER_0_18_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_18_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2183_ _0869_ net12 _0842_ VGND VGND VPWR VPWR _0870_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_23_419 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_7_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_28_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_50_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1967_ _0721_ VGND VGND VPWR VPWR _0733_ sky130_fd_sc_hd__buf_4
X_3706_ _1810_ VGND VGND VPWR VPWR _0599_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_55_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_31_496 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3637_ _1026_ net647 _1770_ VGND VGND VPWR VPWR _1774_ sky130_fd_sc_hd__mux2_1
XFILLER_0_70_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_11_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3568_ _0913_ net784 _1737_ VGND VGND VPWR VPWR _1738_ sky130_fd_sc_hd__mux2_1
X_2519_ instance_1.data\[0\]\[21\] instance_1.data\[1\]\[21\] instance_1.data\[2\]\[21\]
+ instance_1.data\[3\]\[21\] _1109_ _1122_ VGND VGND VPWR VPWR _1130_ sky130_fd_sc_hd__mux4_1
X_3499_ _1701_ VGND VGND VPWR VPWR _0501_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_39_574 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_38_115 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_38_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_49_Left_142 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_81_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_22_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_34_376 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_58_Left_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_89_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold6 instance_1.rdata\[13\] VGND VGND VPWR VPWR net156 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_89_549 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_73_897 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_57_435 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2870_ net719 _1016_ _1369_ VGND VGND VPWR VPWR _1370_ sky130_fd_sc_hd__mux2_1
XPHY_EDGE_ROW_67_Left_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_84_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_44_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_80_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4540_ clknet_leaf_58_clk _0580_ VGND VGND VPWR VPWR instance_1.data\[0\]\[4\] sky130_fd_sc_hd__dfxtp_1
Xclkbuf_leaf_10_clk clknet_3_2__leaf_clk VGND VGND VPWR VPWR clknet_leaf_10_clk sky130_fd_sc_hd__clkbuf_8
Xhold406 instance_1.data\[0\]\[44\] VGND VGND VPWR VPWR net556 sky130_fd_sc_hd__dlygate4sd3_1
Xhold417 instance_2.data\[1\]\[7\] VGND VGND VPWR VPWR net567 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_13_549 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4471_ clknet_leaf_56_clk _0511_ VGND VGND VPWR VPWR instance_2.rdata\[7\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_4_259 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_20_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_52_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold428 instance_1.data\[2\]\[47\] VGND VGND VPWR VPWR net578 sky130_fd_sc_hd__dlygate4sd3_1
Xhold439 instance_1.data\[2\]\[58\] VGND VGND VPWR VPWR net589 sky130_fd_sc_hd__dlygate4sd3_1
X_3422_ _1661_ VGND VGND VPWR VPWR _0464_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_0_432 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3353_ _1624_ VGND VGND VPWR VPWR _1625_ sky130_fd_sc_hd__buf_4
X_2304_ _0963_ VGND VGND VPWR VPWR _0044_ sky130_fd_sc_hd__clkbuf_1
X_3284_ _1588_ VGND VGND VPWR VPWR _0399_ sky130_fd_sc_hd__clkbuf_1
X_2235_ _0720_ VGND VGND VPWR VPWR _0910_ sky130_fd_sc_hd__buf_4
X_2166_ _0856_ net8 _0842_ VGND VGND VPWR VPWR _0857_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_36_544 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2097_ net1 VGND VGND VPWR VPWR _0801_ sky130_fd_sc_hd__clkbuf_8
XFILLER_0_0_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_75_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_3_Right_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_16_332 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_16_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_28_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2999_ _0979_ net282 _1428_ VGND VGND VPWR VPWR _1438_ sky130_fd_sc_hd__mux2_1
XFILLER_0_16_354 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_31_313 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4669_ clknet_leaf_2_clk _0709_ VGND VGND VPWR VPWR instance_2.data\[3\]\[61\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_31_346 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_39_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_39_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_70_867 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_81_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_34_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_78_945 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2020_ instance_1.rdata\[35\] instance_2.rdata\[35\] _0755_ VGND VGND VPWR VPWR _0761_
+ sky130_fd_sc_hd__mux2_1
Xclkbuf_leaf_59_clk clknet_3_1__leaf_clk VGND VGND VPWR VPWR clknet_leaf_59_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_0_82_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3971_ clknet_leaf_49_clk _0011_ VGND VGND VPWR VPWR instance_2.data\[2\]\[11\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_9_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2922_ _0853_ net668 _1395_ VGND VGND VPWR VPWR _1398_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_33_514 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_57_254 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_45_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2853_ net293 _0989_ _1358_ VGND VGND VPWR VPWR _1361_ sky130_fd_sc_hd__mux2_1
X_2784_ _1324_ VGND VGND VPWR VPWR _0163_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_41_591 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_60_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_13_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4523_ clknet_leaf_11_clk _0563_ VGND VGND VPWR VPWR instance_2.rdata\[59\] sky130_fd_sc_hd__dfxtp_1
Xhold225 instance_1.data\[3\]\[8\] VGND VGND VPWR VPWR net375 sky130_fd_sc_hd__dlygate4sd3_1
Xhold203 instance_2.data\[1\]\[67\] VGND VGND VPWR VPWR net353 sky130_fd_sc_hd__dlygate4sd3_1
Xhold214 instance_1.rdata\[31\] VGND VGND VPWR VPWR net364 sky130_fd_sc_hd__dlygate4sd3_1
Xhold258 instance_1.data\[1\]\[38\] VGND VGND VPWR VPWR net408 sky130_fd_sc_hd__dlygate4sd3_1
Xhold269 instance_2.rdata\[49\] VGND VGND VPWR VPWR net419 sky130_fd_sc_hd__dlygate4sd3_1
Xhold247 instance_1.data\[1\]\[13\] VGND VGND VPWR VPWR net397 sky130_fd_sc_hd__dlygate4sd3_1
Xhold236 instance_2.data\[3\]\[9\] VGND VGND VPWR VPWR net386 sky130_fd_sc_hd__dlygate4sd3_1
X_4454_ clknet_leaf_1_clk _0494_ VGND VGND VPWR VPWR instance_1.data\[2\]\[62\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_0_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3405_ _1652_ VGND VGND VPWR VPWR _0456_ sky130_fd_sc_hd__clkbuf_1
X_4385_ clknet_leaf_5_clk _0425_ VGND VGND VPWR VPWR instance_1.rdata\[65\] sky130_fd_sc_hd__dfxtp_1
X_3336_ net373 _1276_ _1611_ VGND VGND VPWR VPWR _1616_ sky130_fd_sc_hd__mux2_1
XFILLER_0_56_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3267_ net364 _1164_ _1578_ VGND VGND VPWR VPWR _1580_ sky130_fd_sc_hd__mux2_1
X_3198_ net776 _1298_ _1464_ VGND VGND VPWR VPWR _1543_ sky130_fd_sc_hd__mux2_1
X_2218_ _0896_ net21 _0876_ VGND VGND VPWR VPWR _0897_ sky130_fd_sc_hd__mux2_1
X_2149_ net391 _0843_ _0813_ VGND VGND VPWR VPWR _0844_ sky130_fd_sc_hd__mux2_1
XFILLER_0_72_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_63_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_63_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_16_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_75_915 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_83_992 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_79_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_10_296 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4170_ clknet_leaf_9_clk _0210_ VGND VGND VPWR VPWR instance_2.data\[1\]\[66\] sky130_fd_sc_hd__dfxtp_1
X_3121_ net672 _1175_ _1498_ VGND VGND VPWR VPWR _1503_ sky130_fd_sc_hd__mux2_1
X_3052_ net450 _1064_ _1465_ VGND VGND VPWR VPWR _1467_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_85_1011 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2003_ instance_1.rdata\[27\] instance_2.rdata\[27\] _0744_ VGND VGND VPWR VPWR _0752_
+ sky130_fd_sc_hd__mux2_1
XFILLER_0_77_316 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_26_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_18_374 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_73_500 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3954_ net617 _1046_ _1931_ VGND VGND VPWR VPWR _1941_ sky130_fd_sc_hd__mux2_1
X_3885_ net469 _0934_ _1898_ VGND VGND VPWR VPWR _1905_ sky130_fd_sc_hd__mux2_1
X_2905_ _0826_ net846 _1384_ VGND VGND VPWR VPWR _1389_ sky130_fd_sc_hd__mux2_1
XFILLER_0_33_419 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_45_268 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_60_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2836_ net610 _0962_ _1347_ VGND VGND VPWR VPWR _1352_ sky130_fd_sc_hd__mux2_1
XFILLER_0_5_354 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2767_ net431 _0850_ _1314_ VGND VGND VPWR VPWR _1316_ sky130_fd_sc_hd__mux2_1
XFILLER_0_5_376 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_41_452 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_53_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_77_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2698_ net555 _1268_ _1264_ VGND VGND VPWR VPWR _1269_ sky130_fd_sc_hd__mux2_1
X_4506_ clknet_leaf_24_clk _0546_ VGND VGND VPWR VPWR instance_2.rdata\[42\] sky130_fd_sc_hd__dfxtp_1
X_4437_ clknet_leaf_19_clk _0477_ VGND VGND VPWR VPWR instance_1.data\[2\]\[45\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_6_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4368_ clknet_leaf_19_clk _0408_ VGND VGND VPWR VPWR instance_1.rdata\[48\] sky130_fd_sc_hd__dfxtp_1
X_4299_ clknet_leaf_15_clk _0339_ VGND VGND VPWR VPWR instance_1.data\[3\]\[51\] sky130_fd_sc_hd__dfxtp_1
X_3319_ net740 _1249_ _1600_ VGND VGND VPWR VPWR _1607_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_80_962 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_52_697 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_17_493 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_59_316 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_15_344 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_12_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3670_ _1791_ VGND VGND VPWR VPWR _0582_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_27_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2621_ net42 _1208_ _1199_ VGND VGND VPWR VPWR _1209_ sky130_fd_sc_hd__mux2_1
Xoutput105 net105 VGND VGND VPWR VPWR rdata[35] sky130_fd_sc_hd__clkbuf_4
Xoutput116 net116 VGND VGND VPWR VPWR rdata[45] sky130_fd_sc_hd__clkbuf_4
X_2552_ _1155_ VGND VGND VPWR VPWR _0100_ sky130_fd_sc_hd__clkbuf_1
Xoutput127 net127 VGND VGND VPWR VPWR rdata[55] sky130_fd_sc_hd__clkbuf_4
Xoutput138 net138 VGND VGND VPWR VPWR rdata[65] sky130_fd_sc_hd__clkbuf_4
X_2483_ _1102_ VGND VGND VPWR VPWR _0084_ sky130_fd_sc_hd__clkbuf_1
X_4222_ clknet_leaf_23_clk _0262_ VGND VGND VPWR VPWR instance_2.data\[0\]\[46\] sky130_fd_sc_hd__dfxtp_1
X_4153_ clknet_leaf_6_clk _0193_ VGND VGND VPWR VPWR instance_2.data\[1\]\[49\] sky130_fd_sc_hd__dfxtp_1
X_4084_ clknet_leaf_16_clk _0124_ VGND VGND VPWR VPWR instance_1.data\[1\]\[52\] sky130_fd_sc_hd__dfxtp_1
X_3104_ net639 _1148_ _1487_ VGND VGND VPWR VPWR _1494_ sky130_fd_sc_hd__mux2_1
X_3035_ _1036_ net780 _1450_ VGND VGND VPWR VPWR _1457_ sky130_fd_sc_hd__mux2_1
XFILLER_0_77_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_46_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3937_ _1932_ VGND VGND VPWR VPWR _0708_ sky130_fd_sc_hd__clkbuf_1
XPHY_EDGE_ROW_12_Left_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3868_ net247 _0907_ _1887_ VGND VGND VPWR VPWR _1896_ sky130_fd_sc_hd__mux2_1
X_2819_ net169 _0934_ _1336_ VGND VGND VPWR VPWR _1343_ sky130_fd_sc_hd__mux2_1
X_3799_ net491 _1289_ _1850_ VGND VGND VPWR VPWR _1859_ sky130_fd_sc_hd__mux2_1
XFILLER_0_61_547 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_21_Left_114 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_57_745 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_30_Left_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_12_314 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xinput18 wdata[22] VGND VGND VPWR VPWR net18 sky130_fd_sc_hd__buf_1
XFILLER_0_91_193 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xinput29 wdata[32] VGND VGND VPWR VPWR net29 sky130_fd_sc_hd__buf_1
XTAP_TAPCELL_ROW_20_391 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_32_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_74_38 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_90_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_87_444 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_87_466 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_87_499 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_74_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_74_127 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_28_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_86 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1983_ _0741_ VGND VGND VPWR VPWR net85 sky130_fd_sc_hd__buf_1
XFILLER_0_55_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3722_ net688 _1166_ _1817_ VGND VGND VPWR VPWR _1819_ sky130_fd_sc_hd__mux2_1
X_3653_ _1051_ net814 _1300_ VGND VGND VPWR VPWR _1782_ sky130_fd_sc_hd__mux2_1
X_2604_ _1059_ VGND VGND VPWR VPWR _1196_ sky130_fd_sc_hd__buf_4
X_3584_ _0940_ net754 _1737_ VGND VGND VPWR VPWR _1746_ sky130_fd_sc_hd__mux2_1
XFILLER_0_11_422 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_11_444 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2535_ _1142_ VGND VGND VPWR VPWR _0096_ sky130_fd_sc_hd__clkbuf_1
X_2466_ instance_1.data\[0\]\[9\] instance_1.data\[1\]\[9\] instance_1.data\[2\]\[9\]
+ instance_1.data\[3\]\[9\] _1075_ _1088_ VGND VGND VPWR VPWR _1089_ sky130_fd_sc_hd__mux4_1
XFILLER_0_48_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_48_72 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_48_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4205_ clknet_leaf_37_clk _0245_ VGND VGND VPWR VPWR instance_2.data\[0\]\[29\] sky130_fd_sc_hd__dfxtp_1
X_2397_ instance_2.data\[0\]\[66\] instance_2.data\[1\]\[66\] instance_2.data\[2\]\[66\]
+ instance_2.data\[3\]\[66\] _1025_ _1004_ VGND VGND VPWR VPWR _1035_ sky130_fd_sc_hd__mux4_1
X_4136_ clknet_leaf_35_clk _0176_ VGND VGND VPWR VPWR instance_2.data\[1\]\[32\] sky130_fd_sc_hd__dfxtp_1
X_4067_ clknet_leaf_30_clk _0107_ VGND VGND VPWR VPWR instance_1.data\[1\]\[35\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_78_433 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_54_715 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3018_ _1009_ net828 _1439_ VGND VGND VPWR VPWR _1448_ sky130_fd_sc_hd__mux2_1
XFILLER_0_19_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_62_792 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_56_105 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_37_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_71_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_52_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_4_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2320_ net593 _0975_ _0949_ VGND VGND VPWR VPWR _0976_ sky130_fd_sc_hd__mux2_1
XFILLER_0_85_48 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2251_ _0922_ VGND VGND VPWR VPWR _0032_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_18_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2182_ instance_2.data\[0\]\[17\] instance_2.data\[1\]\[17\] instance_2.data\[2\]\[17\]
+ instance_2.data\[3\]\[17\] _0855_ _0868_ VGND VGND VPWR VPWR _0869_ sky130_fd_sc_hd__mux4_1
XFILLER_0_26_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_87_230 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_75_458 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1966_ _0732_ VGND VGND VPWR VPWR net148 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_7_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3705_ net716 _1138_ _1806_ VGND VGND VPWR VPWR _1810_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_31_497 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3636_ _1773_ VGND VGND VPWR VPWR _0566_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_59_60 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3567_ _1300_ VGND VGND VPWR VPWR _1737_ sky130_fd_sc_hd__buf_4
X_2518_ _1129_ VGND VGND VPWR VPWR _0092_ sky130_fd_sc_hd__clkbuf_1
X_3498_ net667 _1292_ _1691_ VGND VGND VPWR VPWR _1701_ sky130_fd_sc_hd__mux2_1
X_2449_ instance_1.data\[0\]\[5\] instance_1.data\[1\]\[5\] instance_1.data\[2\]\[5\]
+ instance_1.data\[3\]\[5\] _1075_ _1054_ VGND VGND VPWR VPWR _1076_ sky130_fd_sc_hd__mux4_1
XFILLER_0_75_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_75_92 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4119_ clknet_leaf_50_clk _0159_ VGND VGND VPWR VPWR instance_2.data\[1\]\[15\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_67_840 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_78_274 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_22_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_61_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_6_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_34_388 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold7 instance_2.data\[2\]\[0\] VGND VGND VPWR VPWR net157 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_89_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_29_116 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_37_182 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_4_227 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xhold407 instance_1.data\[3\]\[56\] VGND VGND VPWR VPWR net557 sky130_fd_sc_hd__dlygate4sd3_1
X_4470_ clknet_leaf_58_clk _0510_ VGND VGND VPWR VPWR instance_2.rdata\[6\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_20_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xhold418 instance_1.data\[0\]\[30\] VGND VGND VPWR VPWR net568 sky130_fd_sc_hd__dlygate4sd3_1
Xhold429 instance_1.data\[0\]\[64\] VGND VGND VPWR VPWR net579 sky130_fd_sc_hd__dlygate4sd3_1
X_3421_ net378 _1169_ _1658_ VGND VGND VPWR VPWR _1661_ sky130_fd_sc_hd__mux2_1
XFILLER_0_0_455 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3352_ _0808_ _1544_ _1054_ VGND VGND VPWR VPWR _1624_ sky130_fd_sc_hd__nor3b_4
X_2303_ net845 _0962_ _0949_ VGND VGND VPWR VPWR _0963_ sky130_fd_sc_hd__mux2_1
X_3283_ net344 _1191_ _1578_ VGND VGND VPWR VPWR _1588_ sky130_fd_sc_hd__mux2_1
X_2234_ instance_2.data\[0\]\[29\] instance_2.data\[1\]\[29\] instance_2.data\[2\]\[29\]
+ instance_2.data\[3\]\[29\] _0889_ _0902_ VGND VGND VPWR VPWR _0909_ sky130_fd_sc_hd__mux4_1
XTAP_TAPCELL_ROW_88_1031 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2165_ instance_2.data\[0\]\[13\] instance_2.data\[1\]\[13\] instance_2.data\[2\]\[13\]
+ instance_2.data\[3\]\[13\] _0855_ _0834_ VGND VGND VPWR VPWR _0856_ sky130_fd_sc_hd__mux4_1
XFILLER_0_24_6 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_64_810 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2096_ _0800_ VGND VGND VPWR VPWR net145 sky130_fd_sc_hd__buf_1
XTAP_TAPCELL_ROW_36_545 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_75_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_0_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_8_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2998_ _1437_ VGND VGND VPWR VPWR _0264_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_16_344 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1949_ instance_1.rdata\[1\] instance_2.rdata\[1\] _0722_ VGND VGND VPWR VPWR _0724_
+ sky130_fd_sc_hd__mux2_1
XFILLER_0_9_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4668_ clknet_leaf_10_clk _0708_ VGND VGND VPWR VPWR instance_2.data\[3\]\[60\] sky130_fd_sc_hd__dfxtp_1
X_3619_ _1764_ VGND VGND VPWR VPWR _0558_ sky130_fd_sc_hd__clkbuf_1
X_4599_ clknet_leaf_1_clk _0639_ VGND VGND VPWR VPWR instance_1.data\[0\]\[63\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_79_550 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_39_403 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_39_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_70_868 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_34_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_62_450 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_7_270 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_13_Right_13 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_82_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_82_16 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3970_ clknet_leaf_50_clk _0010_ VGND VGND VPWR VPWR instance_2.data\[2\]\[10\] sky130_fd_sc_hd__dfxtp_1
X_2921_ _1397_ VGND VGND VPWR VPWR _0227_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_33_515 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_57_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_45_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2852_ _1360_ VGND VGND VPWR VPWR _0195_ sky130_fd_sc_hd__clkbuf_1
XPHY_EDGE_ROW_22_Right_22 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2783_ net637 _0877_ _1314_ VGND VGND VPWR VPWR _1324_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_41_592 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_13_314 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4522_ clknet_leaf_11_clk _0562_ VGND VGND VPWR VPWR instance_2.rdata\[58\] sky130_fd_sc_hd__dfxtp_1
Xhold215 instance_1.data\[3\]\[38\] VGND VGND VPWR VPWR net365 sky130_fd_sc_hd__dlygate4sd3_1
Xhold204 instance_1.data\[3\]\[12\] VGND VGND VPWR VPWR net354 sky130_fd_sc_hd__dlygate4sd3_1
Xhold226 instance_2.data\[2\]\[17\] VGND VGND VPWR VPWR net376 sky130_fd_sc_hd__dlygate4sd3_1
X_4453_ clknet_leaf_1_clk _0493_ VGND VGND VPWR VPWR instance_1.data\[2\]\[61\] sky130_fd_sc_hd__dfxtp_1
Xhold248 instance_1.data\[0\]\[42\] VGND VGND VPWR VPWR net398 sky130_fd_sc_hd__dlygate4sd3_1
Xhold259 instance_1.rdata\[10\] VGND VGND VPWR VPWR net409 sky130_fd_sc_hd__dlygate4sd3_1
Xhold237 instance_2.data\[2\]\[13\] VGND VGND VPWR VPWR net387 sky130_fd_sc_hd__dlygate4sd3_1
X_3404_ net499 _1141_ _1647_ VGND VGND VPWR VPWR _1652_ sky130_fd_sc_hd__mux2_1
X_4384_ clknet_leaf_3_clk _0424_ VGND VGND VPWR VPWR instance_1.rdata\[64\] sky130_fd_sc_hd__dfxtp_1
X_3335_ _1615_ VGND VGND VPWR VPWR _0423_ sky130_fd_sc_hd__clkbuf_1
XPHY_EDGE_ROW_31_Right_31 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3266_ _1579_ VGND VGND VPWR VPWR _0390_ sky130_fd_sc_hd__clkbuf_1
X_2217_ instance_2.data\[0\]\[25\] instance_2.data\[1\]\[25\] instance_2.data\[2\]\[25\]
+ instance_2.data\[3\]\[25\] _0889_ _0868_ VGND VGND VPWR VPWR _0896_ sky130_fd_sc_hd__mux4_1
XFILLER_0_22_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3197_ _1542_ VGND VGND VPWR VPWR _0358_ sky130_fd_sc_hd__clkbuf_1
X_2148_ _0841_ net75 _0842_ VGND VGND VPWR VPWR _0843_ sky130_fd_sc_hd__mux2_1
X_2079_ instance_1.rdata\[63\] instance_2.rdata\[63\] _0788_ VGND VGND VPWR VPWR _0792_
+ sky130_fd_sc_hd__mux2_1
XFILLER_0_48_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_29_491 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_40_Right_40 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_63_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_16_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_86_Left_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_31_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_4_240 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_75_916 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_54_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_10_297 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_10_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_22_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_50_486 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3120_ _1502_ VGND VGND VPWR VPWR _0321_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_89_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3051_ _1466_ VGND VGND VPWR VPWR _0288_ sky130_fd_sc_hd__clkbuf_1
X_2002_ _0751_ VGND VGND VPWR VPWR net95 sky130_fd_sc_hd__buf_1
XTAP_TAPCELL_ROW_46_640 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_18_375 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_92_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_18_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_42_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3953_ _1940_ VGND VGND VPWR VPWR _0716_ sky130_fd_sc_hd__clkbuf_1
X_2904_ _1388_ VGND VGND VPWR VPWR _0219_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_45_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3884_ _1904_ VGND VGND VPWR VPWR _0683_ sky130_fd_sc_hd__clkbuf_1
X_2835_ _1351_ VGND VGND VPWR VPWR _0187_ sky130_fd_sc_hd__clkbuf_1
X_2766_ _1315_ VGND VGND VPWR VPWR _0154_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_5_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4505_ clknet_leaf_25_clk _0545_ VGND VGND VPWR VPWR instance_2.rdata\[41\] sky130_fd_sc_hd__dfxtp_1
X_2697_ net61 _1266_ _1267_ VGND VGND VPWR VPWR _1268_ sky130_fd_sc_hd__mux2_1
X_4436_ clknet_leaf_26_clk _0476_ VGND VGND VPWR VPWR instance_1.data\[2\]\[44\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_6_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4367_ clknet_leaf_19_clk _0407_ VGND VGND VPWR VPWR instance_1.rdata\[47\] sky130_fd_sc_hd__dfxtp_1
X_3318_ _1606_ VGND VGND VPWR VPWR _0415_ sky130_fd_sc_hd__clkbuf_1
X_4298_ clknet_leaf_17_clk _0338_ VGND VGND VPWR VPWR instance_1.data\[3\]\[50\] sky130_fd_sc_hd__dfxtp_1
X_3249_ _1570_ VGND VGND VPWR VPWR _0382_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_1_210 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_68_317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_80_963 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_64_523 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_52_698 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xhold590 instance_1.rdata\[56\] VGND VGND VPWR VPWR net740 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_43_610 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_74_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_67_350 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_15_345 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_82_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2620_ instance_1.data\[0\]\[44\] instance_1.data\[1\]\[44\] instance_1.data\[2\]\[44\]
+ instance_1.data\[3\]\[44\] _1177_ _1190_ VGND VGND VPWR VPWR _1208_ sky130_fd_sc_hd__mux4_1
XFILLER_0_88_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput106 net106 VGND VGND VPWR VPWR rdata[36] sky130_fd_sc_hd__buf_2
X_2551_ net284 _1154_ _1128_ VGND VGND VPWR VPWR _1155_ sky130_fd_sc_hd__mux2_1
XFILLER_0_50_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xoutput117 net117 VGND VGND VPWR VPWR rdata[46] sky130_fd_sc_hd__clkbuf_4
Xoutput128 net128 VGND VGND VPWR VPWR rdata[56] sky130_fd_sc_hd__clkbuf_4
X_2482_ net263 _1101_ _1094_ VGND VGND VPWR VPWR _1102_ sky130_fd_sc_hd__mux2_1
Xoutput139 net139 VGND VGND VPWR VPWR rdata[66] sky130_fd_sc_hd__clkbuf_4
X_4221_ clknet_leaf_21_clk _0261_ VGND VGND VPWR VPWR instance_2.data\[0\]\[45\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_91_1060 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4152_ clknet_leaf_20_clk _0192_ VGND VGND VPWR VPWR instance_2.data\[1\]\[48\] sky130_fd_sc_hd__dfxtp_1
X_4083_ clknet_leaf_17_clk _0123_ VGND VGND VPWR VPWR instance_1.data\[1\]\[51\] sky130_fd_sc_hd__dfxtp_1
X_3103_ _1493_ VGND VGND VPWR VPWR _0313_ sky130_fd_sc_hd__clkbuf_1
X_3034_ _1456_ VGND VGND VPWR VPWR _0281_ sky130_fd_sc_hd__clkbuf_1
X_3936_ net394 _1016_ _1931_ VGND VGND VPWR VPWR _1932_ sky130_fd_sc_hd__mux2_1
XFILLER_0_18_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_46_545 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_33_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3867_ _1895_ VGND VGND VPWR VPWR _0675_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_26_291 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3798_ _1858_ VGND VGND VPWR VPWR _0643_ sky130_fd_sc_hd__clkbuf_1
X_2818_ _1342_ VGND VGND VPWR VPWR _0179_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_14_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2749_ _1306_ VGND VGND VPWR VPWR _0146_ sky130_fd_sc_hd__clkbuf_1
X_4419_ clknet_leaf_35_clk _0459_ VGND VGND VPWR VPWR instance_1.data\[2\]\[27\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_68_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_68_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_56_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_12_315 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_91_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xinput19 wdata[23] VGND VGND VPWR VPWR net19 sky130_fd_sc_hd__buf_1
XTAP_TAPCELL_ROW_20_392 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_32_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_90_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_87_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_28_470 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1982_ instance_1.rdata\[17\] instance_2.rdata\[17\] _0733_ VGND VGND VPWR VPWR _0741_
+ sky130_fd_sc_hd__mux2_1
XFILLER_0_28_545 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_67_180 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3721_ _1818_ VGND VGND VPWR VPWR _0606_ sky130_fd_sc_hd__clkbuf_1
X_3652_ _1781_ VGND VGND VPWR VPWR _0574_ sky130_fd_sc_hd__clkbuf_1
X_3583_ _1745_ VGND VGND VPWR VPWR _0541_ sky130_fd_sc_hd__clkbuf_1
X_2603_ net38 _1194_ _1165_ VGND VGND VPWR VPWR _1195_ sky130_fd_sc_hd__mux2_1
XFILLER_0_11_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2534_ net272 _1141_ _1128_ VGND VGND VPWR VPWR _1142_ sky130_fd_sc_hd__mux2_1
XFILLER_0_11_434 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_11_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2465_ _0803_ VGND VGND VPWR VPWR _1088_ sky130_fd_sc_hd__buf_4
X_4204_ clknet_leaf_22_clk _0244_ VGND VGND VPWR VPWR instance_2.data\[0\]\[28\] sky130_fd_sc_hd__dfxtp_1
X_2396_ _1034_ VGND VGND VPWR VPWR _0065_ sky130_fd_sc_hd__clkbuf_1
X_4135_ clknet_leaf_32_clk _0175_ VGND VGND VPWR VPWR instance_2.data\[1\]\[31\] sky130_fd_sc_hd__dfxtp_1
X_4066_ clknet_leaf_31_clk _0106_ VGND VGND VPWR VPWR instance_1.data\[1\]\[34\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_78_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_54_716 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3017_ _1447_ VGND VGND VPWR VPWR _0273_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_80_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_19_545 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_62_793 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_73_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3919_ net318 _0989_ _1920_ VGND VGND VPWR VPWR _1923_ sky130_fd_sc_hd__mux2_1
XFILLER_0_46_397 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_6_494 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_61_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_25_440 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_56_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_69_Right_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_56_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_52_323 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_78_Right_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2250_ net288 _0921_ _0915_ VGND VGND VPWR VPWR _0922_ sky130_fd_sc_hd__mux2_1
X_2181_ _0803_ VGND VGND VPWR VPWR _0868_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_34_20 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_87_Right_87 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_87_242 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_28_342 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1965_ instance_1.rdata\[9\] instance_2.rdata\[9\] _0722_ VGND VGND VPWR VPWR _0732_
+ sky130_fd_sc_hd__mux2_1
XFILLER_0_7_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_7_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3704_ _1809_ VGND VGND VPWR VPWR _0598_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_43_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_50_63 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_50_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_31_498 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_70_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3635_ _1022_ net864 _1770_ VGND VGND VPWR VPWR _1773_ sky130_fd_sc_hd__mux2_1
XFILLER_0_70_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3566_ _1736_ VGND VGND VPWR VPWR _0533_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_11_264 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3497_ _1700_ VGND VGND VPWR VPWR _0500_ sky130_fd_sc_hd__clkbuf_1
X_2517_ net265 _1127_ _1128_ VGND VGND VPWR VPWR _1129_ sky130_fd_sc_hd__mux2_1
X_2448_ _0801_ VGND VGND VPWR VPWR _1075_ sky130_fd_sc_hd__buf_4
X_2379_ _1021_ VGND VGND VPWR VPWR _0061_ sky130_fd_sc_hd__clkbuf_1
X_4118_ clknet_leaf_47_clk _0158_ VGND VGND VPWR VPWR instance_2.data\[1\]\[14\] sky130_fd_sc_hd__dfxtp_1
X_4049_ clknet_leaf_42_clk _0089_ VGND VGND VPWR VPWR instance_1.data\[1\]\[17\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_91_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_19_364 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_22_410 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_6_280 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_22_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold8 instance_1.data\[3\]\[0\] VGND VGND VPWR VPWR net158 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_89_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_356 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xhold408 instance_1.data\[0\]\[47\] VGND VGND VPWR VPWR net558 sky130_fd_sc_hd__dlygate4sd3_1
Xmax_cap149 _1624_ VGND VGND VPWR VPWR net149 sky130_fd_sc_hd__buf_4
X_3420_ _1660_ VGND VGND VPWR VPWR _0463_ sky130_fd_sc_hd__clkbuf_1
Xhold419 instance_2.data\[1\]\[33\] VGND VGND VPWR VPWR net569 sky130_fd_sc_hd__dlygate4sd3_1
X_3351_ _1623_ VGND VGND VPWR VPWR _0431_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_29_20 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2302_ _0961_ net42 _0944_ VGND VGND VPWR VPWR _0962_ sky130_fd_sc_hd__mux2_1
X_3282_ _1587_ VGND VGND VPWR VPWR _0398_ sky130_fd_sc_hd__clkbuf_1
X_2233_ _0908_ VGND VGND VPWR VPWR _0028_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_88_1032 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2164_ _0801_ VGND VGND VPWR VPWR _0855_ sky130_fd_sc_hd__buf_4
XTAP_TAPCELL_ROW_64_811 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_88_551 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2095_ instance_1.rdata\[71\] instance_2.rdata\[71\] _0721_ VGND VGND VPWR VPWR _0800_
+ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_36_546 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_75_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_8_545 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2997_ _0975_ net811 _1428_ VGND VGND VPWR VPWR _1437_ sky130_fd_sc_hd__mux2_1
X_1948_ _0723_ VGND VGND VPWR VPWR net77 sky130_fd_sc_hd__buf_1
XFILLER_0_71_484 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4667_ clknet_leaf_10_clk _0707_ VGND VGND VPWR VPWR instance_2.data\[3\]\[59\] sky130_fd_sc_hd__dfxtp_1
X_3618_ _0995_ net605 _1759_ VGND VGND VPWR VPWR _1764_ sky130_fd_sc_hd__mux2_1
XFILLER_0_12_551 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4598_ clknet_leaf_1_clk _0638_ VGND VGND VPWR VPWR instance_1.data\[0\]\[62\] sky130_fd_sc_hd__dfxtp_1
X_3549_ _0883_ net863 _1726_ VGND VGND VPWR VPWR _1728_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_70_869 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_66_256 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_22_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_30_392 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_78_936 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_85_521 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2920_ _0850_ net826 _1395_ VGND VGND VPWR VPWR _1397_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_33_516 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_57_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_57_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2851_ net539 _0986_ _1358_ VGND VGND VPWR VPWR _1360_ sky130_fd_sc_hd__mux2_1
X_2782_ _1323_ VGND VGND VPWR VPWR _0162_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_41_593 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4521_ clknet_leaf_13_clk _0561_ VGND VGND VPWR VPWR instance_2.rdata\[57\] sky130_fd_sc_hd__dfxtp_1
Xhold216 instance_1.data\[1\]\[14\] VGND VGND VPWR VPWR net366 sky130_fd_sc_hd__dlygate4sd3_1
X_4452_ clknet_leaf_2_clk _0492_ VGND VGND VPWR VPWR instance_1.data\[2\]\[60\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_40_112 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold205 instance_2.data\[1\]\[57\] VGND VGND VPWR VPWR net355 sky130_fd_sc_hd__dlygate4sd3_1
Xhold238 instance_1.data\[1\]\[3\] VGND VGND VPWR VPWR net388 sky130_fd_sc_hd__dlygate4sd3_1
X_3403_ _1651_ VGND VGND VPWR VPWR _0455_ sky130_fd_sc_hd__clkbuf_1
Xhold227 instance_2.data\[0\]\[26\] VGND VGND VPWR VPWR net377 sky130_fd_sc_hd__dlygate4sd3_1
Xhold249 instance_1.data\[3\]\[30\] VGND VGND VPWR VPWR net399 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_0_231 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_0_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4383_ clknet_leaf_2_clk _0423_ VGND VGND VPWR VPWR instance_1.rdata\[63\] sky130_fd_sc_hd__dfxtp_1
X_3334_ net269 _1273_ _1611_ VGND VGND VPWR VPWR _1615_ sky130_fd_sc_hd__mux2_1
X_3265_ net645 _1160_ _1578_ VGND VGND VPWR VPWR _1579_ sky130_fd_sc_hd__mux2_1
X_2216_ _0895_ VGND VGND VPWR VPWR _0024_ sky130_fd_sc_hd__clkbuf_1
X_3196_ net417 _1295_ _1464_ VGND VGND VPWR VPWR _1542_ sky130_fd_sc_hd__mux2_1
XFILLER_0_15_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2147_ _0720_ VGND VGND VPWR VPWR _0842_ sky130_fd_sc_hd__buf_4
X_2078_ _0791_ VGND VGND VPWR VPWR net135 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_63_237 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_4_241 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_86_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_82_546 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_50_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_10_298 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_10_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3050_ net158 _1056_ _1465_ VGND VGND VPWR VPWR _1466_ sky130_fd_sc_hd__mux2_1
X_2001_ instance_1.rdata\[26\] instance_2.rdata\[26\] _0744_ VGND VGND VPWR VPWR _0751_
+ sky130_fd_sc_hd__mux2_1
XFILLER_0_89_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_46_641 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_58_510 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3952_ net802 _1042_ _1931_ VGND VGND VPWR VPWR _1940_ sky130_fd_sc_hd__mux2_1
XFILLER_0_73_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2903_ _0823_ net465 _1384_ VGND VGND VPWR VPWR _1388_ sky130_fd_sc_hd__mux2_1
X_3883_ net640 _0931_ _1898_ VGND VGND VPWR VPWR _1904_ sky130_fd_sc_hd__mux2_1
XFILLER_0_5_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2834_ net413 _0959_ _1347_ VGND VGND VPWR VPWR _1351_ sky130_fd_sc_hd__mux2_1
X_2765_ net687 _0846_ _1314_ VGND VGND VPWR VPWR _1315_ sky130_fd_sc_hd__mux2_1
XFILLER_0_26_495 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4504_ clknet_leaf_23_clk _0544_ VGND VGND VPWR VPWR instance_2.rdata\[40\] sky130_fd_sc_hd__dfxtp_1
X_2696_ _1045_ VGND VGND VPWR VPWR _1267_ sky130_fd_sc_hd__buf_4
X_4435_ clknet_leaf_26_clk _0475_ VGND VGND VPWR VPWR instance_1.data\[2\]\[43\] sky130_fd_sc_hd__dfxtp_1
X_4366_ clknet_leaf_19_clk _0406_ VGND VGND VPWR VPWR instance_1.rdata\[46\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_6_53 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3317_ net259 _1246_ _1600_ VGND VGND VPWR VPWR _1606_ sky130_fd_sc_hd__mux2_1
X_4297_ clknet_leaf_16_clk _0337_ VGND VGND VPWR VPWR instance_1.data\[3\]\[49\] sky130_fd_sc_hd__dfxtp_1
X_3248_ net356 _1134_ _1567_ VGND VGND VPWR VPWR _1570_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_1_211 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3179_ _1533_ VGND VGND VPWR VPWR _0349_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_68_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_80_964 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_32_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_44_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_4_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold580 instance_1.data\[1\]\[15\] VGND VGND VPWR VPWR net730 sky130_fd_sc_hd__dlygate4sd3_1
Xhold591 instance_2.data\[3\]\[65\] VGND VGND VPWR VPWR net741 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_43_611 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_15_346 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_82_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_70_527 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_88_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xoutput107 net107 VGND VGND VPWR VPWR rdata[37] sky130_fd_sc_hd__clkbuf_4
X_2550_ net24 _1153_ _1131_ VGND VGND VPWR VPWR _1154_ sky130_fd_sc_hd__mux2_1
Xoutput118 net118 VGND VGND VPWR VPWR rdata[47] sky130_fd_sc_hd__clkbuf_4
Xoutput129 net129 VGND VGND VPWR VPWR rdata[57] sky130_fd_sc_hd__clkbuf_4
X_2481_ net7 _1100_ _1097_ VGND VGND VPWR VPWR _1101_ sky130_fd_sc_hd__mux2_1
X_4220_ clknet_leaf_23_clk _0260_ VGND VGND VPWR VPWR instance_2.data\[0\]\[44\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_91_1061 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4151_ clknet_leaf_21_clk _0191_ VGND VGND VPWR VPWR instance_2.data\[1\]\[47\] sky130_fd_sc_hd__dfxtp_1
X_4082_ clknet_leaf_17_clk _0122_ VGND VGND VPWR VPWR instance_1.data\[1\]\[50\] sky130_fd_sc_hd__dfxtp_1
X_3102_ net548 _1145_ _1487_ VGND VGND VPWR VPWR _1493_ sky130_fd_sc_hd__mux2_1
X_3033_ _1033_ net734 _1450_ VGND VGND VPWR VPWR _1456_ sky130_fd_sc_hd__mux2_1
XFILLER_0_53_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_58_340 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3935_ _1864_ VGND VGND VPWR VPWR _1931_ sky130_fd_sc_hd__buf_4
XFILLER_0_58_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3866_ net493 _0904_ _1887_ VGND VGND VPWR VPWR _1895_ sky130_fd_sc_hd__mux2_1
XFILLER_0_61_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_82_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_26_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3797_ net691 _1286_ _1850_ VGND VGND VPWR VPWR _1858_ sky130_fd_sc_hd__mux2_1
X_2817_ net324 _0931_ _1336_ VGND VGND VPWR VPWR _1342_ sky130_fd_sc_hd__mux2_1
X_2748_ net182 _0819_ _1303_ VGND VGND VPWR VPWR _1306_ sky130_fd_sc_hd__mux2_1
XFILLER_0_5_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2679_ net447 _1253_ _1230_ VGND VGND VPWR VPWR _1254_ sky130_fd_sc_hd__mux2_1
X_4418_ clknet_leaf_41_clk _0458_ VGND VGND VPWR VPWR instance_1.data\[2\]\[26\] sky130_fd_sc_hd__dfxtp_1
X_4349_ clknet_leaf_37_clk _0389_ VGND VGND VPWR VPWR instance_1.rdata\[29\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_68_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_49_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_12_316 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_17_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_20_393 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_23_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_55_310 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1981_ _0740_ VGND VGND VPWR VPWR net84 sky130_fd_sc_hd__clkbuf_1
X_3720_ net568 _1161_ _1817_ VGND VGND VPWR VPWR _1818_ sky130_fd_sc_hd__mux2_1
Xclkbuf_leaf_40_clk clknet_3_5__leaf_clk VGND VGND VPWR VPWR clknet_leaf_40_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_0_55_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3651_ _1048_ net708 _1300_ VGND VGND VPWR VPWR _1781_ sky130_fd_sc_hd__mux2_1
X_2602_ instance_1.data\[0\]\[40\] instance_1.data\[1\]\[40\] instance_1.data\[2\]\[40\]
+ instance_1.data\[3\]\[40\] _1177_ _1190_ VGND VGND VPWR VPWR _1194_ sky130_fd_sc_hd__mux4_1
X_3582_ _0937_ net509 _1737_ VGND VGND VPWR VPWR _1745_ sky130_fd_sc_hd__mux2_1
XFILLER_0_70_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2533_ net20 _1140_ _1131_ VGND VGND VPWR VPWR _1141_ sky130_fd_sc_hd__mux2_1
X_2464_ _1087_ VGND VGND VPWR VPWR _0080_ sky130_fd_sc_hd__clkbuf_1
X_4203_ clknet_leaf_37_clk _0243_ VGND VGND VPWR VPWR instance_2.data\[0\]\[27\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_48_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2395_ net795 _1033_ _1017_ VGND VGND VPWR VPWR _1034_ sky130_fd_sc_hd__mux2_1
X_4134_ clknet_leaf_36_clk _0174_ VGND VGND VPWR VPWR instance_2.data\[1\]\[30\] sky130_fd_sc_hd__dfxtp_1
X_4065_ clknet_leaf_31_clk _0105_ VGND VGND VPWR VPWR instance_1.data\[1\]\[33\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_54_717 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3016_ _1006_ net737 _1439_ VGND VGND VPWR VPWR _1447_ sky130_fd_sc_hd__mux2_1
XFILLER_0_78_468 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_80_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_19_502 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xclkbuf_leaf_31_clk clknet_3_7__leaf_clk VGND VGND VPWR VPWR clknet_leaf_31_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_0_46_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3918_ _1922_ VGND VGND VPWR VPWR _0699_ sky130_fd_sc_hd__clkbuf_1
X_3849_ net664 _0877_ _1876_ VGND VGND VPWR VPWR _1886_ sky130_fd_sc_hd__mux2_1
XFILLER_0_89_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_490 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_25_441 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_77_490 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_49_181 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_leaf_22_clk clknet_3_6__leaf_clk VGND VGND VPWR VPWR clknet_leaf_22_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_0_64_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_40_508 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_0_Left_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2180_ _0867_ VGND VGND VPWR VPWR _0016_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_18_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_87_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_87_254 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_87_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_90_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_leaf_13_clk clknet_3_2__leaf_clk VGND VGND VPWR VPWR clknet_leaf_13_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_0_16_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1964_ _0731_ VGND VGND VPWR VPWR net147 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_28_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3703_ net219 _1135_ _1806_ VGND VGND VPWR VPWR _1809_ sky130_fd_sc_hd__mux2_1
XFILLER_0_43_313 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3634_ _1772_ VGND VGND VPWR VPWR _0565_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_50_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3565_ _0909_ net851 _1726_ VGND VGND VPWR VPWR _1736_ sky130_fd_sc_hd__mux2_1
X_3496_ net670 _1289_ _1691_ VGND VGND VPWR VPWR _1700_ sky130_fd_sc_hd__mux2_1
X_2516_ _1059_ VGND VGND VPWR VPWR _1128_ sky130_fd_sc_hd__buf_4
X_2447_ _1074_ VGND VGND VPWR VPWR _0076_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_45_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2378_ net472 _1020_ _1017_ VGND VGND VPWR VPWR _1021_ sky130_fd_sc_hd__mux2_1
X_4117_ clknet_leaf_48_clk _0157_ VGND VGND VPWR VPWR instance_2.data\[1\]\[13\] sky130_fd_sc_hd__dfxtp_1
X_4048_ clknet_leaf_44_clk _0088_ VGND VGND VPWR VPWR instance_1.data\[1\]\[16\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_39_566 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_91_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_66_416 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_19_354 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_22_411 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_18_Left_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold9 instance_2.data\[2\]\[27\] VGND VGND VPWR VPWR net159 sky130_fd_sc_hd__dlygate4sd3_1
XPHY_EDGE_ROW_27_Left_120 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_69_210 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_69_254 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_73_889 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_25_346 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold409 instance_2.data\[2\]\[10\] VGND VGND VPWR VPWR net559 sky130_fd_sc_hd__dlygate4sd3_1
X_3350_ net367 _1297_ _1544_ VGND VGND VPWR VPWR _1623_ sky130_fd_sc_hd__mux2_1
XFILLER_0_29_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2301_ instance_2.data\[0\]\[44\] instance_2.data\[1\]\[44\] instance_2.data\[2\]\[44\]
+ instance_2.data\[3\]\[44\] _0957_ _0936_ VGND VGND VPWR VPWR _0961_ sky130_fd_sc_hd__mux4_1
X_3281_ net403 _1187_ _1578_ VGND VGND VPWR VPWR _1587_ sky130_fd_sc_hd__mux2_1
Xclkbuf_leaf_2_clk clknet_3_0__leaf_clk VGND VGND VPWR VPWR clknet_leaf_2_clk sky130_fd_sc_hd__clkbuf_8
X_2232_ net671 _0907_ _0881_ VGND VGND VPWR VPWR _0908_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_88_1033 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2163_ _0854_ VGND VGND VPWR VPWR _0012_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_31_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2094_ _0799_ VGND VGND VPWR VPWR net144 sky130_fd_sc_hd__buf_1
XTAP_TAPCELL_ROW_64_812 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_75_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_75_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_56_493 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2996_ _1436_ VGND VGND VPWR VPWR _0263_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_90_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1947_ instance_1.rdata\[0\] instance_2.rdata\[0\] _0722_ VGND VGND VPWR VPWR _0723_
+ sky130_fd_sc_hd__mux2_1
XFILLER_0_43_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_43_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4666_ clknet_leaf_11_clk _0706_ VGND VGND VPWR VPWR instance_2.data\[3\]\[58\] sky130_fd_sc_hd__dfxtp_1
X_3617_ _1763_ VGND VGND VPWR VPWR _0557_ sky130_fd_sc_hd__clkbuf_1
X_4597_ clknet_leaf_1_clk _0637_ VGND VGND VPWR VPWR instance_1.data\[0\]\[61\] sky130_fd_sc_hd__dfxtp_1
X_3548_ _1727_ VGND VGND VPWR VPWR _0524_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_86_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_86_71 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3479_ net149 VGND VGND VPWR VPWR _1691_ sky130_fd_sc_hd__buf_4
XFILLER_0_81_205 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_327 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_22_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_78_937 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_85_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_33_517 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2850_ _1359_ VGND VGND VPWR VPWR _0194_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_5_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_72_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2781_ net152 _0873_ _1314_ VGND VGND VPWR VPWR _1323_ sky130_fd_sc_hd__mux2_1
XFILLER_0_25_143 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_31_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_80_271 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_5_549 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_40_102 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_53_463 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_53_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4520_ clknet_leaf_13_clk _0560_ VGND VGND VPWR VPWR instance_2.rdata\[56\] sky130_fd_sc_hd__dfxtp_1
X_4451_ clknet_leaf_14_clk _0491_ VGND VGND VPWR VPWR instance_1.data\[2\]\[59\] sky130_fd_sc_hd__dfxtp_1
Xhold217 instance_1.rdata\[71\] VGND VGND VPWR VPWR net367 sky130_fd_sc_hd__dlygate4sd3_1
Xhold206 instance_1.rdata\[22\] VGND VGND VPWR VPWR net356 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_40_124 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold239 instance_1.data\[1\]\[71\] VGND VGND VPWR VPWR net389 sky130_fd_sc_hd__dlygate4sd3_1
X_3402_ net543 _1138_ _1647_ VGND VGND VPWR VPWR _1651_ sky130_fd_sc_hd__mux2_1
XFILLER_0_40_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xhold228 instance_1.data\[2\]\[32\] VGND VGND VPWR VPWR net378 sky130_fd_sc_hd__dlygate4sd3_1
X_4382_ clknet_leaf_1_clk _0422_ VGND VGND VPWR VPWR instance_1.rdata\[62\] sky130_fd_sc_hd__dfxtp_1
X_3333_ _1614_ VGND VGND VPWR VPWR _0422_ sky130_fd_sc_hd__clkbuf_1
XPHY_EDGE_ROW_7_Right_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3264_ _1544_ VGND VGND VPWR VPWR _1578_ sky130_fd_sc_hd__buf_4
X_2215_ net753 _0894_ _0881_ VGND VGND VPWR VPWR _0895_ sky130_fd_sc_hd__mux2_1
X_3195_ _1541_ VGND VGND VPWR VPWR _0357_ sky130_fd_sc_hd__clkbuf_1
X_2146_ instance_2.data\[0\]\[9\] instance_2.data\[1\]\[9\] instance_2.data\[2\]\[9\]
+ instance_2.data\[3\]\[9\] _0821_ _0834_ VGND VGND VPWR VPWR _0841_ sky130_fd_sc_hd__mux4_1
XTAP_TAPCELL_ROW_49_661 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2077_ instance_1.rdata\[62\] instance_2.rdata\[62\] _0788_ VGND VGND VPWR VPWR _0791_
+ sky130_fd_sc_hd__mux2_1
XFILLER_0_76_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_72_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_91_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_8_387 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_8_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2979_ _1427_ VGND VGND VPWR VPWR _0255_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_63_249 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4649_ clknet_leaf_23_clk _0689_ VGND VGND VPWR VPWR instance_2.data\[3\]\[41\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_12_371 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_4_242 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_83_984 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_67_522 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_82_536 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_82_514 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_39_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_22_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_62_271 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_10_299 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_89_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2000_ _0750_ VGND VGND VPWR VPWR net94 sky130_fd_sc_hd__buf_1
XTAP_TAPCELL_ROW_85_1003 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_26_44 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_18_366 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3951_ _1939_ VGND VGND VPWR VPWR _0715_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_58_522 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_58_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2902_ _1387_ VGND VGND VPWR VPWR _0218_ sky130_fd_sc_hd__clkbuf_1
X_3882_ _1903_ VGND VGND VPWR VPWR _0682_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_45_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2833_ _1350_ VGND VGND VPWR VPWR _0186_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_5_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2764_ _1302_ VGND VGND VPWR VPWR _1314_ sky130_fd_sc_hd__buf_4
XFILLER_0_84_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_13_102 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4503_ clknet_leaf_36_clk _0543_ VGND VGND VPWR VPWR instance_2.rdata\[39\] sky130_fd_sc_hd__dfxtp_1
X_2695_ instance_1.data\[0\]\[61\] instance_1.data\[1\]\[61\] instance_1.data\[2\]\[61\]
+ instance_1.data\[3\]\[61\] _1245_ _1258_ VGND VGND VPWR VPWR _1266_ sky130_fd_sc_hd__mux4_1
XFILLER_0_41_466 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4434_ clknet_leaf_27_clk _0474_ VGND VGND VPWR VPWR instance_1.data\[2\]\[42\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_1_541 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4365_ clknet_leaf_19_clk _0405_ VGND VGND VPWR VPWR instance_1.rdata\[45\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_6_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3316_ _1605_ VGND VGND VPWR VPWR _0414_ sky130_fd_sc_hd__clkbuf_1
X_4296_ clknet_leaf_18_clk _0336_ VGND VGND VPWR VPWR instance_1.data\[3\]\[48\] sky130_fd_sc_hd__dfxtp_1
X_3247_ _1569_ VGND VGND VPWR VPWR _0381_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_1_212 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3178_ net777 _1268_ _1531_ VGND VGND VPWR VPWR _1533_ sky130_fd_sc_hd__mux2_1
X_2129_ instance_2.data\[0\]\[5\] instance_2.data\[1\]\[5\] instance_2.data\[2\]\[5\]
+ instance_2.data\[3\]\[5\] _0821_ _0804_ VGND VGND VPWR VPWR _0828_ sky130_fd_sc_hd__mux4_1
XFILLER_0_49_522 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_76_374 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_76_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_29_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_36_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_52_689 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xhold581 instance_1.rdata\[3\] VGND VGND VPWR VPWR net731 sky130_fd_sc_hd__dlygate4sd3_1
Xhold570 instance_2.data\[0\]\[28\] VGND VGND VPWR VPWR net720 sky130_fd_sc_hd__dlygate4sd3_1
Xhold592 instance_1.data\[3\]\[64\] VGND VGND VPWR VPWR net742 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_43_612 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_55_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_82_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_82_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_70_506 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xoutput108 net108 VGND VGND VPWR VPWR rdata[38] sky130_fd_sc_hd__clkbuf_4
Xoutput119 net119 VGND VGND VPWR VPWR rdata[48] sky130_fd_sc_hd__clkbuf_4
XFILLER_0_10_116 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2480_ instance_1.data\[0\]\[12\] instance_1.data\[1\]\[12\] instance_1.data\[2\]\[12\]
+ instance_1.data\[3\]\[12\] _1075_ _1088_ VGND VGND VPWR VPWR _1100_ sky130_fd_sc_hd__mux4_1
XFILLER_0_10_127 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_91_1062 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4150_ clknet_leaf_21_clk _0190_ VGND VGND VPWR VPWR instance_2.data\[1\]\[46\] sky130_fd_sc_hd__dfxtp_1
Xoutput90 net90 VGND VGND VPWR VPWR rdata[21] sky130_fd_sc_hd__buf_2
X_3101_ _1492_ VGND VGND VPWR VPWR _0312_ sky130_fd_sc_hd__clkbuf_1
X_4081_ clknet_leaf_17_clk _0121_ VGND VGND VPWR VPWR instance_1.data\[1\]\[49\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_37_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3032_ _1455_ VGND VGND VPWR VPWR _0280_ sky130_fd_sc_hd__clkbuf_1
X_3934_ _1930_ VGND VGND VPWR VPWR _0707_ sky130_fd_sc_hd__clkbuf_1
X_3865_ _1894_ VGND VGND VPWR VPWR _0674_ sky130_fd_sc_hd__clkbuf_1
X_2816_ _1341_ VGND VGND VPWR VPWR _0178_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_5_154 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3796_ _1857_ VGND VGND VPWR VPWR _0642_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_14_433 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2747_ _1305_ VGND VGND VPWR VPWR _0145_ sky130_fd_sc_hd__clkbuf_1
X_2678_ net56 _1252_ _1233_ VGND VGND VPWR VPWR _1253_ sky130_fd_sc_hd__mux2_1
XFILLER_0_78_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4417_ clknet_leaf_39_clk _0457_ VGND VGND VPWR VPWR instance_1.data\[2\]\[25\] sky130_fd_sc_hd__dfxtp_1
X_4348_ clknet_leaf_37_clk _0388_ VGND VGND VPWR VPWR instance_1.rdata\[28\] sky130_fd_sc_hd__dfxtp_1
X_4279_ clknet_leaf_33_clk _0319_ VGND VGND VPWR VPWR instance_1.data\[3\]\[31\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_57_737 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_49_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_37_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_76_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_12_317 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_9_482 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_52_506 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_20_414 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_20_425 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_20_394 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_90_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_28_461 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1980_ instance_1.rdata\[16\] instance_2.rdata\[16\] _0733_ VGND VGND VPWR VPWR _0740_
+ sky130_fd_sc_hd__mux2_1
X_3650_ _1780_ VGND VGND VPWR VPWR _0573_ sky130_fd_sc_hd__clkbuf_1
X_2601_ _1193_ VGND VGND VPWR VPWR _0111_ sky130_fd_sc_hd__clkbuf_1
X_3581_ _1744_ VGND VGND VPWR VPWR _0540_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_70_347 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2532_ instance_1.data\[0\]\[24\] instance_1.data\[1\]\[24\] instance_1.data\[2\]\[24\]
+ instance_1.data\[3\]\[24\] _1109_ _1122_ VGND VGND VPWR VPWR _1140_ sky130_fd_sc_hd__mux4_1
X_2463_ net516 _1086_ _1060_ VGND VGND VPWR VPWR _1087_ sky130_fd_sc_hd__mux2_1
X_4202_ clknet_leaf_38_clk _0242_ VGND VGND VPWR VPWR instance_2.data\[0\]\[26\] sky130_fd_sc_hd__dfxtp_1
X_2394_ _1032_ net65 _1012_ VGND VGND VPWR VPWR _1033_ sky130_fd_sc_hd__mux2_1
X_4133_ clknet_leaf_37_clk _0173_ VGND VGND VPWR VPWR instance_2.data\[1\]\[29\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_3_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4064_ clknet_leaf_33_clk _0104_ VGND VGND VPWR VPWR instance_1.data\[1\]\[32\] sky130_fd_sc_hd__dfxtp_1
X_3015_ _1446_ VGND VGND VPWR VPWR _0272_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_58_182 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_62_784 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3917_ net693 _0986_ _1920_ VGND VGND VPWR VPWR _1922_ sky130_fd_sc_hd__mux2_1
X_3848_ _1885_ VGND VGND VPWR VPWR _0666_ sky130_fd_sc_hd__clkbuf_1
X_3779_ _1848_ VGND VGND VPWR VPWR _0634_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_89_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_84_439 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_49_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_28_322 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1963_ instance_1.rdata\[8\] instance_2.rdata\[8\] _0722_ VGND VGND VPWR VPWR _0731_
+ sky130_fd_sc_hd__mux2_1
XFILLER_0_55_152 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_16_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_28_377 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3702_ _1808_ VGND VGND VPWR VPWR _0597_ sky130_fd_sc_hd__clkbuf_1
X_3633_ _1019_ net830 _1770_ VGND VGND VPWR VPWR _1772_ sky130_fd_sc_hd__mux2_1
X_3564_ _1735_ VGND VGND VPWR VPWR _0532_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_59_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2515_ net16 _1126_ _1097_ VGND VGND VPWR VPWR _1127_ sky130_fd_sc_hd__mux2_1
X_3495_ _1699_ VGND VGND VPWR VPWR _0499_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_11_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2446_ net820 _1073_ _1060_ VGND VGND VPWR VPWR _1074_ sky130_fd_sc_hd__mux2_1
XFILLER_0_75_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_75_40 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4116_ clknet_leaf_49_clk _0156_ VGND VGND VPWR VPWR instance_2.data\[1\]\[12\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_38_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2377_ _1019_ net61 _1012_ VGND VGND VPWR VPWR _1020_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_67_832 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4047_ clknet_leaf_43_clk _0087_ VGND VGND VPWR VPWR instance_1.data\[1\]\[15\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_39_567 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_59_491 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_22_412 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_69_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_69_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_25_314 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_37_196 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_80_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_33_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_0_436 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3280_ _1586_ VGND VGND VPWR VPWR _0397_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_0_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2300_ _0960_ VGND VGND VPWR VPWR _0043_ sky130_fd_sc_hd__clkbuf_1
X_2231_ _0906_ net24 _0876_ VGND VGND VPWR VPWR _0907_ sky130_fd_sc_hd__mux2_1
X_2162_ net303 _0853_ _0847_ VGND VGND VPWR VPWR _0854_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_88_1034 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2093_ instance_1.rdata\[70\] instance_2.rdata\[70\] _0721_ VGND VGND VPWR VPWR _0799_
+ sky130_fd_sc_hd__mux2_1
XFILLER_0_45_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_88_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_45_87 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_36_537 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_8_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2995_ _0972_ net755 _1428_ VGND VGND VPWR VPWR _1436_ sky130_fd_sc_hd__mux2_1
XFILLER_0_71_431 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1946_ _0721_ VGND VGND VPWR VPWR _0722_ sky130_fd_sc_hd__buf_4
XFILLER_0_43_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_43_133 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4665_ clknet_leaf_11_clk _0705_ VGND VGND VPWR VPWR instance_2.data\[3\]\[57\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_12_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4596_ clknet_leaf_2_clk _0636_ VGND VGND VPWR VPWR instance_1.data\[0\]\[60\] sky130_fd_sc_hd__dfxtp_1
X_3616_ _0992_ net787 _1759_ VGND VGND VPWR VPWR _1763_ sky130_fd_sc_hd__mux2_1
X_3547_ _0879_ net858 _1726_ VGND VGND VPWR VPWR _1727_ sky130_fd_sc_hd__mux2_1
X_3478_ _1690_ VGND VGND VPWR VPWR _0491_ sky130_fd_sc_hd__clkbuf_1
X_2429_ net174 _1056_ _1060_ VGND VGND VPWR VPWR _1061_ sky130_fd_sc_hd__mux2_1
XFILLER_0_81_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_47_483 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_74_291 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_7_262 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_78_938 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_15_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_85_545 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_72_228 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_5_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2780_ _1322_ VGND VGND VPWR VPWR _0161_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_80_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xhold207 instance_1.data\[3\]\[51\] VGND VGND VPWR VPWR net357 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_80_294 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4450_ clknet_leaf_14_clk _0490_ VGND VGND VPWR VPWR instance_1.data\[2\]\[58\] sky130_fd_sc_hd__dfxtp_1
Xhold229 instance_1.data\[2\]\[38\] VGND VGND VPWR VPWR net379 sky130_fd_sc_hd__dlygate4sd3_1
Xhold218 instance_1.rdata\[16\] VGND VGND VPWR VPWR net368 sky130_fd_sc_hd__dlygate4sd3_1
X_4381_ clknet_leaf_1_clk _0421_ VGND VGND VPWR VPWR instance_1.rdata\[61\] sky130_fd_sc_hd__dfxtp_1
X_3401_ _1650_ VGND VGND VPWR VPWR _0454_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_0_244 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_21_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3332_ net700 _1270_ _1611_ VGND VGND VPWR VPWR _1614_ sky130_fd_sc_hd__mux2_1
X_3263_ _1577_ VGND VGND VPWR VPWR _0389_ sky130_fd_sc_hd__clkbuf_1
X_3194_ net574 _1292_ _1531_ VGND VGND VPWR VPWR _1541_ sky130_fd_sc_hd__mux2_1
X_2214_ _0893_ net20 _0876_ VGND VGND VPWR VPWR _0894_ sky130_fd_sc_hd__mux2_1
X_2145_ _0840_ VGND VGND VPWR VPWR _0008_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_49_662 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_88_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2076_ _0790_ VGND VGND VPWR VPWR net134 sky130_fd_sc_hd__clkbuf_1
Xclkbuf_3_5__f_clk clknet_0_clk VGND VGND VPWR VPWR clknet_3_5__leaf_clk sky130_fd_sc_hd__clkbuf_16
XFILLER_0_8_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_29_483 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_46_Left_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2978_ _0945_ net390 _1417_ VGND VGND VPWR VPWR _1427_ sky130_fd_sc_hd__mux2_1
XFILLER_0_44_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4648_ clknet_leaf_22_clk _0688_ VGND VGND VPWR VPWR instance_2.data\[3\]\[40\] sky130_fd_sc_hd__dfxtp_1
X_4579_ clknet_leaf_26_clk _0619_ VGND VGND VPWR VPWR instance_1.data\[0\]\[43\] sky130_fd_sc_hd__dfxtp_1
XPHY_EDGE_ROW_55_Left_148 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_75_908 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_83_985 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_64_Left_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_67_534 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_35_442 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_35_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_50_467 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_73_Left_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_89_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_85_1004 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_26_56 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold90 instance_2.data\[3\]\[5\] VGND VGND VPWR VPWR net240 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_89_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_82_Left_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_46_632 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_18_367 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3950_ net644 _1039_ _1931_ VGND VGND VPWR VPWR _1939_ sky130_fd_sc_hd__mux2_1
X_2901_ _0819_ net683 _1384_ VGND VGND VPWR VPWR _1387_ sky130_fd_sc_hd__mux2_1
X_3881_ net407 _0928_ _1898_ VGND VGND VPWR VPWR _1903_ sky130_fd_sc_hd__mux2_1
XFILLER_0_42_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_73_548 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_38_280 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2832_ net381 _0955_ _1347_ VGND VGND VPWR VPWR _1350_ sky130_fd_sc_hd__mux2_1
X_2763_ _1313_ VGND VGND VPWR VPWR _0153_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_26_442 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4502_ clknet_leaf_28_clk _0542_ VGND VGND VPWR VPWR instance_2.rdata\[38\] sky130_fd_sc_hd__dfxtp_1
XPHY_EDGE_ROW_91_Left_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2694_ _1265_ VGND VGND VPWR VPWR _0132_ sky130_fd_sc_hd__clkbuf_1
X_4433_ clknet_leaf_26_clk _0473_ VGND VGND VPWR VPWR instance_1.data\[2\]\[41\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_41_478 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4364_ clknet_leaf_25_clk _0404_ VGND VGND VPWR VPWR instance_1.rdata\[44\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_21_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4295_ clknet_leaf_18_clk _0335_ VGND VGND VPWR VPWR instance_1.data\[3\]\[47\] sky130_fd_sc_hd__dfxtp_1
X_3315_ net181 _1242_ _1600_ VGND VGND VPWR VPWR _1605_ sky130_fd_sc_hd__mux2_1
X_3246_ net457 _1130_ _1567_ VGND VGND VPWR VPWR _1569_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_1_213 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_20_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3177_ _1532_ VGND VGND VPWR VPWR _0348_ sky130_fd_sc_hd__clkbuf_1
X_2128_ _0827_ VGND VGND VPWR VPWR _0004_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_49_534 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2059_ _0781_ VGND VGND VPWR VPWR net125 sky130_fd_sc_hd__buf_1
XTAP_TAPCELL_ROW_80_955 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_76_386 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_91_345 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_91_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_44_294 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold560 instance_2.data\[3\]\[20\] VGND VGND VPWR VPWR net710 sky130_fd_sc_hd__dlygate4sd3_1
Xhold571 instance_2.data\[0\]\[46\] VGND VGND VPWR VPWR net721 sky130_fd_sc_hd__dlygate4sd3_1
Xhold582 instance_1.data\[1\]\[54\] VGND VGND VPWR VPWR net732 sky130_fd_sc_hd__dlygate4sd3_1
Xhold593 instance_2.data\[3\]\[47\] VGND VGND VPWR VPWR net743 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_86_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_42_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_88_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput109 net109 VGND VGND VPWR VPWR rdata[39] sky130_fd_sc_hd__buf_2
XFILLER_0_10_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_91_1063 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xoutput80 net80 VGND VGND VPWR VPWR rdata[12] sky130_fd_sc_hd__clkbuf_4
X_3100_ net270 _1141_ _1487_ VGND VGND VPWR VPWR _1492_ sky130_fd_sc_hd__mux2_1
Xoutput91 net91 VGND VGND VPWR VPWR rdata[22] sky130_fd_sc_hd__buf_2
X_4080_ clknet_leaf_18_clk _0120_ VGND VGND VPWR VPWR instance_1.data\[1\]\[48\] sky130_fd_sc_hd__dfxtp_1
X_3031_ _1030_ net855 _1450_ VGND VGND VPWR VPWR _1455_ sky130_fd_sc_hd__mux2_1
XFILLER_0_77_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_92_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3933_ net627 _1013_ _1920_ VGND VGND VPWR VPWR _1930_ sky130_fd_sc_hd__mux2_1
X_3864_ net400 _0900_ _1887_ VGND VGND VPWR VPWR _1894_ sky130_fd_sc_hd__mux2_1
X_2815_ net443 _0928_ _1336_ VGND VGND VPWR VPWR _1341_ sky130_fd_sc_hd__mux2_1
XFILLER_0_14_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_26_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3795_ net686 _1283_ _1850_ VGND VGND VPWR VPWR _1857_ sky130_fd_sc_hd__mux2_1
X_2746_ net470 _0816_ _1303_ VGND VGND VPWR VPWR _1305_ sky130_fd_sc_hd__mux2_1
XFILLER_0_41_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2677_ instance_1.data\[0\]\[57\] instance_1.data\[1\]\[57\] instance_1.data\[2\]\[57\]
+ instance_1.data\[3\]\[57\] _1245_ _1224_ VGND VGND VPWR VPWR _1252_ sky130_fd_sc_hd__mux4_1
X_4416_ clknet_leaf_39_clk _0456_ VGND VGND VPWR VPWR instance_1.data\[2\]\[24\] sky130_fd_sc_hd__dfxtp_1
X_4347_ clknet_leaf_37_clk _0387_ VGND VGND VPWR VPWR instance_1.rdata\[27\] sky130_fd_sc_hd__dfxtp_1
X_4278_ clknet_leaf_34_clk _0318_ VGND VGND VPWR VPWR instance_1.data\[3\]\[30\] sky130_fd_sc_hd__dfxtp_1
X_3229_ net156 _1103_ _1556_ VGND VGND VPWR VPWR _1560_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_57_738 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_12_318 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_64_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_52_518 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_32_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_32_286 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold390 instance_2.data\[2\]\[54\] VGND VGND VPWR VPWR net540 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_28_462 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_23_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_67_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_55_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_55_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2600_ net326 _1192_ _1162_ VGND VGND VPWR VPWR _1193_ sky130_fd_sc_hd__mux2_1
X_3580_ _0933_ net678 _1737_ VGND VGND VPWR VPWR _1744_ sky130_fd_sc_hd__mux2_1
X_2531_ _1139_ VGND VGND VPWR VPWR _0095_ sky130_fd_sc_hd__clkbuf_1
X_2462_ net74 _1085_ _1063_ VGND VGND VPWR VPWR _1086_ sky130_fd_sc_hd__mux2_1
X_4201_ clknet_leaf_53_clk _0241_ VGND VGND VPWR VPWR instance_2.data\[0\]\[25\] sky130_fd_sc_hd__dfxtp_1
X_2393_ instance_2.data\[0\]\[65\] instance_2.data\[1\]\[65\] instance_2.data\[2\]\[65\]
+ instance_2.data\[3\]\[65\] _1025_ _1004_ VGND VGND VPWR VPWR _1032_ sky130_fd_sc_hd__mux4_1
X_4132_ clknet_leaf_22_clk _0172_ VGND VGND VPWR VPWR instance_2.data\[1\]\[28\] sky130_fd_sc_hd__dfxtp_1
X_4063_ clknet_leaf_33_clk _0103_ VGND VGND VPWR VPWR instance_1.data\[1\]\[31\] sky130_fd_sc_hd__dfxtp_1
X_3014_ _1002_ net602 _1439_ VGND VGND VPWR VPWR _1446_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_54_708 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_64_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_80_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_62_785 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3916_ _1921_ VGND VGND VPWR VPWR _0698_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_80_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_73_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_34_507 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_73_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3847_ net763 _0873_ _1876_ VGND VGND VPWR VPWR _1885_ sky130_fd_sc_hd__mux2_1
X_3778_ net531 _1256_ _1839_ VGND VGND VPWR VPWR _1848_ sky130_fd_sc_hd__mux2_1
XFILLER_0_6_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_14_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2729_ net69 _1291_ _1267_ VGND VGND VPWR VPWR _1292_ sky130_fd_sc_hd__mux2_1
XPHY_EDGE_ROW_29_Right_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_77_470 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_37_356 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_25_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_38_Right_38 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_33_540 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_64_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_47_Right_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_87_212 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1962_ _0730_ VGND VGND VPWR VPWR net146 sky130_fd_sc_hd__clkbuf_1
XPHY_EDGE_ROW_56_Right_56 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_16_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_28_389 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3701_ net410 _1132_ _1806_ VGND VGND VPWR VPWR _1808_ sky130_fd_sc_hd__mux2_1
XFILLER_0_43_326 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_55_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_70_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_43_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3632_ _1771_ VGND VGND VPWR VPWR _0564_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_3_423 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_11_212 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_11_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3563_ _0906_ net808 _1726_ VGND VGND VPWR VPWR _1735_ sky130_fd_sc_hd__mux2_1
X_3494_ net246 _1286_ _1691_ VGND VGND VPWR VPWR _1699_ sky130_fd_sc_hd__mux2_1
X_2514_ instance_1.data\[0\]\[20\] instance_1.data\[1\]\[20\] instance_1.data\[2\]\[20\]
+ instance_1.data\[3\]\[20\] _1109_ _1122_ VGND VGND VPWR VPWR _1126_ sky130_fd_sc_hd__mux4_1
X_2445_ net48 _1072_ _1063_ VGND VGND VPWR VPWR _1073_ sky130_fd_sc_hd__mux2_1
XFILLER_0_52_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_65_Right_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4115_ clknet_leaf_49_clk _0155_ VGND VGND VPWR VPWR instance_2.data\[1\]\[11\] sky130_fd_sc_hd__dfxtp_1
X_2376_ instance_2.data\[0\]\[61\] instance_2.data\[1\]\[61\] instance_2.data\[2\]\[61\]
+ instance_2.data\[3\]\[61\] _0991_ _1004_ VGND VGND VPWR VPWR _1019_ sky130_fd_sc_hd__mux4_1
XTAP_TAPCELL_ROW_67_833 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4046_ clknet_leaf_45_clk _0086_ VGND VGND VPWR VPWR instance_1.data\[1\]\[14\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_39_568 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_91_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_38_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_74_Right_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_22_413 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_19_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_46_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_6_272 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_30_521 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_61_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_83_Right_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_92_Right_92 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_37_153 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_92_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2230_ instance_2.data\[0\]\[28\] instance_2.data\[1\]\[28\] instance_2.data\[2\]\[28\]
+ instance_2.data\[3\]\[28\] _0889_ _0902_ VGND VGND VPWR VPWR _0906_ sky130_fd_sc_hd__mux4_1
X_2161_ _0852_ net7 _0842_ VGND VGND VPWR VPWR _0853_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_88_1035 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2092_ _0798_ VGND VGND VPWR VPWR net142 sky130_fd_sc_hd__buf_1
XTAP_TAPCELL_ROW_64_803 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_36_538 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_0_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_72_880 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_61_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2994_ _1435_ VGND VGND VPWR VPWR _0262_ sky130_fd_sc_hd__clkbuf_1
X_1945_ _0720_ VGND VGND VPWR VPWR _0721_ sky130_fd_sc_hd__clkbuf_8
XFILLER_0_83_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_28_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_9_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_31_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_43_145 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4664_ clknet_leaf_11_clk _0704_ VGND VGND VPWR VPWR instance_2.data\[3\]\[56\] sky130_fd_sc_hd__dfxtp_1
X_4595_ clknet_leaf_14_clk _0635_ VGND VGND VPWR VPWR instance_1.data\[0\]\[59\] sky130_fd_sc_hd__dfxtp_1
X_3615_ _1762_ VGND VGND VPWR VPWR _0556_ sky130_fd_sc_hd__clkbuf_1
X_3546_ _1300_ VGND VGND VPWR VPWR _1726_ sky130_fd_sc_hd__clkbuf_4
X_3477_ net613 _1260_ _1680_ VGND VGND VPWR VPWR _1690_ sky130_fd_sc_hd__mux2_1
XFILLER_0_50_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2428_ _1059_ VGND VGND VPWR VPWR _1060_ sky130_fd_sc_hd__buf_4
X_2359_ _1005_ net56 _0978_ VGND VGND VPWR VPWR _1006_ sky130_fd_sc_hd__mux2_1
X_4029_ clknet_leaf_7_clk _0069_ VGND VGND VPWR VPWR instance_2.data\[2\]\[69\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_19_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_62_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_30_384 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_7_263 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_78_939 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_5_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_31_68 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_80_240 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_25_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xwire150 _1783_ VGND VGND VPWR VPWR net150 sky130_fd_sc_hd__clkbuf_4
XTAP_TAPCELL_ROW_41_585 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xhold208 instance_1.data\[1\]\[58\] VGND VGND VPWR VPWR net358 sky130_fd_sc_hd__dlygate4sd3_1
Xhold219 instance_1.rdata\[40\] VGND VGND VPWR VPWR net369 sky130_fd_sc_hd__dlygate4sd3_1
X_3400_ net227 _1135_ _1647_ VGND VGND VPWR VPWR _1650_ sky130_fd_sc_hd__mux2_1
X_4380_ clknet_leaf_2_clk _0420_ VGND VGND VPWR VPWR instance_1.rdata\[60\] sky130_fd_sc_hd__dfxtp_1
X_3331_ _1613_ VGND VGND VPWR VPWR _0421_ sky130_fd_sc_hd__clkbuf_1
X_3262_ net682 _1157_ _1567_ VGND VGND VPWR VPWR _1577_ sky130_fd_sc_hd__mux2_1
X_3193_ _1540_ VGND VGND VPWR VPWR _0356_ sky130_fd_sc_hd__clkbuf_1
X_2213_ instance_2.data\[0\]\[24\] instance_2.data\[1\]\[24\] instance_2.data\[2\]\[24\]
+ instance_2.data\[3\]\[24\] _0889_ _0868_ VGND VGND VPWR VPWR _0893_ sky130_fd_sc_hd__mux4_1
X_2144_ net302 _0839_ _0813_ VGND VGND VPWR VPWR _0840_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_49_663 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_88_340 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2075_ instance_1.rdata\[61\] instance_2.rdata\[61\] _0788_ VGND VGND VPWR VPWR _0790_
+ sky130_fd_sc_hd__mux2_1
XFILLER_0_72_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_48_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_91_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_91_549 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2977_ _1426_ VGND VGND VPWR VPWR _0254_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_16_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_4_551 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_44_498 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4647_ clknet_leaf_23_clk _0687_ VGND VGND VPWR VPWR instance_2.data\[3\]\[39\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_31_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xhold720 instance_2.rdata\[58\] VGND VGND VPWR VPWR net870 sky130_fd_sc_hd__dlygate4sd3_1
X_4578_ clknet_leaf_27_clk _0618_ VGND VGND VPWR VPWR instance_1.data\[0\]\[42\] sky130_fd_sc_hd__dfxtp_1
X_3529_ _1717_ VGND VGND VPWR VPWR _0515_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_4_233 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_75_909 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_83_986 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_35_410 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_47_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_47_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_62_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_89_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_85_1005 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xhold80 instance_2.data\[3\]\[16\] VGND VGND VPWR VPWR net230 sky130_fd_sc_hd__dlygate4sd3_1
Xhold91 instance_2.data\[2\]\[6\] VGND VGND VPWR VPWR net241 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_26_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_26_68 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_46_633 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_58_502 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_18_368 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2900_ _1386_ VGND VGND VPWR VPWR _0217_ sky130_fd_sc_hd__clkbuf_1
X_3880_ _1902_ VGND VGND VPWR VPWR _0681_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_42_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_26_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2831_ _1349_ VGND VGND VPWR VPWR _0185_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_5_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2762_ net728 _0843_ _1303_ VGND VGND VPWR VPWR _1313_ sky130_fd_sc_hd__mux2_1
X_4501_ clknet_leaf_29_clk _0541_ VGND VGND VPWR VPWR instance_2.rdata\[37\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_5_348 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4432_ clknet_leaf_25_clk _0472_ VGND VGND VPWR VPWR instance_1.data\[2\]\[40\] sky130_fd_sc_hd__dfxtp_1
X_2693_ net536 _1263_ _1264_ VGND VGND VPWR VPWR _1265_ sky130_fd_sc_hd__mux2_1
X_4363_ clknet_leaf_25_clk _0403_ VGND VGND VPWR VPWR instance_1.rdata\[43\] sky130_fd_sc_hd__dfxtp_1
X_4294_ clknet_leaf_18_clk _0334_ VGND VGND VPWR VPWR instance_1.data\[3\]\[46\] sky130_fd_sc_hd__dfxtp_1
X_3314_ _1604_ VGND VGND VPWR VPWR _0413_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_67_75 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3245_ _1568_ VGND VGND VPWR VPWR _0380_ sky130_fd_sc_hd__clkbuf_1
X_3176_ net322 _1263_ _1531_ VGND VGND VPWR VPWR _1532_ sky130_fd_sc_hd__mux2_1
X_2127_ net393 _0826_ _0813_ VGND VGND VPWR VPWR _0827_ sky130_fd_sc_hd__mux2_1
XFILLER_0_13_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2058_ instance_1.rdata\[53\] instance_2.rdata\[53\] _0777_ VGND VGND VPWR VPWR _0781_
+ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_80_956 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_76_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkbuf_leaf_61_clk clknet_3_0__leaf_clk VGND VGND VPWR VPWR clknet_leaf_61_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_0_36_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_91_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_76_398 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_29_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_91_357 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_465 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_498 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xhold561 instance_2.data\[0\]\[8\] VGND VGND VPWR VPWR net711 sky130_fd_sc_hd__dlygate4sd3_1
Xhold550 instance_1.rdata\[62\] VGND VGND VPWR VPWR net700 sky130_fd_sc_hd__dlygate4sd3_1
Xhold572 instance_2.data\[3\]\[42\] VGND VGND VPWR VPWR net722 sky130_fd_sc_hd__dlygate4sd3_1
Xhold583 instance_2.rdata\[46\] VGND VGND VPWR VPWR net733 sky130_fd_sc_hd__dlygate4sd3_1
Xhold594 instance_2.data\[0\]\[62\] VGND VGND VPWR VPWR net744 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_15_338 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_leaf_52_clk clknet_3_4__leaf_clk VGND VGND VPWR VPWR clknet_leaf_52_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_0_12_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_27_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_51_680 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_23_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_91_1064 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xoutput81 net81 VGND VGND VPWR VPWR rdata[13] sky130_fd_sc_hd__clkbuf_4
Xoutput92 net92 VGND VGND VPWR VPWR rdata[23] sky130_fd_sc_hd__buf_2
X_3030_ _1454_ VGND VGND VPWR VPWR _0279_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_85_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkbuf_leaf_43_clk clknet_3_5__leaf_clk VGND VGND VPWR VPWR clknet_leaf_43_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_0_46_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_58_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3932_ _1929_ VGND VGND VPWR VPWR _0706_ sky130_fd_sc_hd__clkbuf_1
X_3863_ _1893_ VGND VGND VPWR VPWR _0673_ sky130_fd_sc_hd__clkbuf_1
X_2814_ _1340_ VGND VGND VPWR VPWR _0177_ sky130_fd_sc_hd__clkbuf_1
X_3794_ _1856_ VGND VGND VPWR VPWR _0641_ sky130_fd_sc_hd__clkbuf_1
X_2745_ _1304_ VGND VGND VPWR VPWR _0144_ sky130_fd_sc_hd__clkbuf_1
X_2676_ _1251_ VGND VGND VPWR VPWR _0128_ sky130_fd_sc_hd__clkbuf_1
X_4415_ clknet_leaf_41_clk _0455_ VGND VGND VPWR VPWR instance_1.data\[2\]\[23\] sky130_fd_sc_hd__dfxtp_1
X_4346_ clknet_leaf_39_clk _0386_ VGND VGND VPWR VPWR instance_1.rdata\[26\] sky130_fd_sc_hd__dfxtp_1
X_4277_ clknet_leaf_37_clk _0317_ VGND VGND VPWR VPWR instance_1.data\[3\]\[29\] sky130_fd_sc_hd__dfxtp_1
X_3228_ _1559_ VGND VGND VPWR VPWR _0372_ sky130_fd_sc_hd__clkbuf_1
X_3159_ net629 _1237_ _1520_ VGND VGND VPWR VPWR _1523_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_57_739 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_37_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_leaf_34_clk clknet_3_7__leaf_clk VGND VGND VPWR VPWR clknet_leaf_34_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_0_64_346 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_20_385 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_2_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold380 instance_2.data\[3\]\[44\] VGND VGND VPWR VPWR net530 sky130_fd_sc_hd__dlygate4sd3_1
Xhold391 instance_2.data\[2\]\[50\] VGND VGND VPWR VPWR net541 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_87_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_28_463 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_leaf_25_clk clknet_3_6__leaf_clk VGND VGND VPWR VPWR clknet_leaf_25_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_0_55_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_67_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_55_379 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_51_541 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2530_ net166 _1138_ _1128_ VGND VGND VPWR VPWR _1139_ sky130_fd_sc_hd__mux2_1
X_2461_ instance_1.data\[0\]\[8\] instance_1.data\[1\]\[8\] instance_1.data\[2\]\[8\]
+ instance_1.data\[3\]\[8\] _1075_ _1054_ VGND VGND VPWR VPWR _1085_ sky130_fd_sc_hd__mux4_1
XFILLER_0_23_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4200_ clknet_leaf_52_clk _0240_ VGND VGND VPWR VPWR instance_2.data\[0\]\[24\] sky130_fd_sc_hd__dfxtp_1
X_2392_ _1031_ VGND VGND VPWR VPWR _0064_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_47_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4131_ clknet_leaf_37_clk _0171_ VGND VGND VPWR VPWR instance_2.data\[1\]\[27\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_48_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4062_ clknet_leaf_34_clk _0102_ VGND VGND VPWR VPWR instance_1.data\[1\]\[30\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_3_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3013_ _1445_ VGND VGND VPWR VPWR _0271_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_54_709 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_leaf_16_clk clknet_3_3__leaf_clk VGND VGND VPWR VPWR clknet_leaf_16_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_0_86_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3915_ net281 _0982_ _1920_ VGND VGND VPWR VPWR _1921_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_62_786 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_73_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_73_154 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3846_ _1884_ VGND VGND VPWR VPWR _0665_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_34_519 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_46_379 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_89_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3777_ _1847_ VGND VGND VPWR VPWR _0633_ sky130_fd_sc_hd__clkbuf_1
X_2728_ instance_1.data\[0\]\[69\] instance_1.data\[1\]\[69\] instance_1.data\[2\]\[69\]
+ instance_1.data\[3\]\[69\] _0802_ _0804_ VGND VGND VPWR VPWR _1291_ sky130_fd_sc_hd__mux4_1
XFILLER_0_14_287 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2659_ _1238_ VGND VGND VPWR VPWR _0124_ sky130_fd_sc_hd__clkbuf_1
X_4329_ clknet_leaf_57_clk _0369_ VGND VGND VPWR VPWR instance_1.rdata\[9\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_25_433 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_77_482 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_37_324 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_9_292 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_45_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1961_ instance_1.rdata\[7\] instance_2.rdata\[7\] _0722_ VGND VGND VPWR VPWR _0730_
+ sky130_fd_sc_hd__mux2_1
X_3700_ _1807_ VGND VGND VPWR VPWR _0596_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_55_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_43_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3631_ _1015_ net600 _1770_ VGND VGND VPWR VPWR _1771_ sky130_fd_sc_hd__mux2_1
X_3562_ _1734_ VGND VGND VPWR VPWR _0531_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_3_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2513_ _1125_ VGND VGND VPWR VPWR _0091_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_51_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_51_382 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3493_ _1698_ VGND VGND VPWR VPWR _0498_ sky130_fd_sc_hd__clkbuf_1
X_2444_ instance_1.data\[0\]\[4\] instance_1.data\[1\]\[4\] instance_1.data\[2\]\[4\]
+ instance_1.data\[3\]\[4\] _0808_ _1054_ VGND VGND VPWR VPWR _1072_ sky130_fd_sc_hd__mux4_1
Xclkbuf_leaf_5_clk clknet_3_1__leaf_clk VGND VGND VPWR VPWR clknet_leaf_5_clk sky130_fd_sc_hd__clkbuf_8
X_2375_ _1018_ VGND VGND VPWR VPWR _0060_ sky130_fd_sc_hd__clkbuf_1
X_4114_ clknet_leaf_50_clk _0154_ VGND VGND VPWR VPWR instance_2.data\[1\]\[10\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_67_834 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4045_ clknet_leaf_45_clk _0085_ VGND VGND VPWR VPWR instance_1.data\[1\]\[13\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_39_569 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3829_ _1875_ VGND VGND VPWR VPWR _0657_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_15_541 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_30_480 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_30_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_69_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_4_Left_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_37_121 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_37_143 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_20_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_80_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_18_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_21_522 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_29_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_29_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2160_ instance_2.data\[0\]\[12\] instance_2.data\[1\]\[12\] instance_2.data\[2\]\[12\]
+ instance_2.data\[3\]\[12\] _0821_ _0834_ VGND VGND VPWR VPWR _0852_ sky130_fd_sc_hd__mux4_1
XTAP_TAPCELL_ROW_88_1036 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2091_ instance_1.rdata\[69\] instance_2.rdata\[69\] _0788_ VGND VGND VPWR VPWR _0798_
+ sky130_fd_sc_hd__mux2_1
XFILLER_0_88_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_64_804 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_36_539 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_72_881 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_0_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2993_ _0968_ net721 _1428_ VGND VGND VPWR VPWR _1435_ sky130_fd_sc_hd__mux2_1
XFILLER_0_16_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1944_ net3 VGND VGND VPWR VPWR _0720_ sky130_fd_sc_hd__buf_4
XFILLER_0_56_474 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_16_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_43_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_56_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4663_ clknet_leaf_11_clk _0703_ VGND VGND VPWR VPWR instance_2.data\[3\]\[55\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_71_466 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_43_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3614_ _0988_ net656 _1759_ VGND VGND VPWR VPWR _1762_ sky130_fd_sc_hd__mux2_1
X_4594_ clknet_leaf_14_clk _0634_ VGND VGND VPWR VPWR instance_1.data\[0\]\[58\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_24_371 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_12_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3545_ _1725_ VGND VGND VPWR VPWR _0523_ sky130_fd_sc_hd__clkbuf_1
X_3476_ _1689_ VGND VGND VPWR VPWR _0490_ sky130_fd_sc_hd__clkbuf_1
X_2427_ _1057_ _1058_ VGND VGND VPWR VPWR _1059_ sky130_fd_sc_hd__nor2_8
XFILLER_0_86_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2358_ instance_2.data\[0\]\[57\] instance_2.data\[1\]\[57\] instance_2.data\[2\]\[57\]
+ instance_2.data\[3\]\[57\] _0991_ _1004_ VGND VGND VPWR VPWR _1005_ sky130_fd_sc_hd__mux4_1
X_2289_ _0951_ net39 _0944_ VGND VGND VPWR VPWR _0952_ sky130_fd_sc_hd__mux2_1
X_4028_ clknet_leaf_7_clk _0068_ VGND VGND VPWR VPWR instance_2.data\[2\]\[68\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_62_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_319 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_30_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_7_264 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_15_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_33_509 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_38_474 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_41_586 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xhold209 instance_1.data\[2\]\[31\] VGND VGND VPWR VPWR net359 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_21_341 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3330_ net562 _1266_ _1611_ VGND VGND VPWR VPWR _1613_ sky130_fd_sc_hd__mux2_1
X_3261_ _1576_ VGND VGND VPWR VPWR _0388_ sky130_fd_sc_hd__clkbuf_1
X_3192_ net402 _1289_ _1531_ VGND VGND VPWR VPWR _1540_ sky130_fd_sc_hd__mux2_1
X_2212_ _0892_ VGND VGND VPWR VPWR _0023_ sky130_fd_sc_hd__clkbuf_1
X_2143_ _0838_ net74 _0806_ VGND VGND VPWR VPWR _0839_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_49_664 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2074_ _0789_ VGND VGND VPWR VPWR net133 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_72_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_91_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2976_ _0941_ net522 _1417_ VGND VGND VPWR VPWR _1426_ sky130_fd_sc_hd__mux2_1
XFILLER_0_8_379 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_56_271 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4646_ clknet_leaf_24_clk _0686_ VGND VGND VPWR VPWR instance_2.data\[3\]\[38\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_21_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4577_ clknet_leaf_27_clk _0617_ VGND VGND VPWR VPWR instance_1.data\[0\]\[41\] sky130_fd_sc_hd__dfxtp_1
Xhold710 instance_2.rdata\[12\] VGND VGND VPWR VPWR net860 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_12_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3528_ _0849_ net854 _1715_ VGND VGND VPWR VPWR _1717_ sky130_fd_sc_hd__mux2_1
X_3459_ net311 _1229_ _1680_ VGND VGND VPWR VPWR _1681_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_4_234 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_79_341 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_83_987 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_22_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_89_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xhold92 instance_1.data\[0\]\[9\] VGND VGND VPWR VPWR net242 sky130_fd_sc_hd__dlygate4sd3_1
Xhold81 instance_2.data\[3\]\[4\] VGND VGND VPWR VPWR net231 sky130_fd_sc_hd__dlygate4sd3_1
Xhold70 instance_2.data\[2\]\[35\] VGND VGND VPWR VPWR net220 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_89_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_85_1006 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_46_634 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_58_514 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_18_369 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2830_ net485 _0952_ _1347_ VGND VGND VPWR VPWR _1349_ sky130_fd_sc_hd__mux2_1
XFILLER_0_38_271 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_42_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2761_ _1312_ VGND VGND VPWR VPWR _0152_ sky130_fd_sc_hd__clkbuf_1
X_4500_ clknet_leaf_30_clk _0540_ VGND VGND VPWR VPWR instance_2.rdata\[36\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_26_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2692_ _1059_ VGND VGND VPWR VPWR _1264_ sky130_fd_sc_hd__buf_4
X_4431_ clknet_leaf_28_clk _0471_ VGND VGND VPWR VPWR instance_1.data\[2\]\[39\] sky130_fd_sc_hd__dfxtp_1
XANTENNA_1 _0803_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_4362_ clknet_leaf_24_clk _0402_ VGND VGND VPWR VPWR instance_1.rdata\[42\] sky130_fd_sc_hd__dfxtp_1
X_4293_ clknet_leaf_19_clk _0333_ VGND VGND VPWR VPWR instance_1.data\[3\]\[45\] sky130_fd_sc_hd__dfxtp_1
X_3313_ net225 _1239_ _1600_ VGND VGND VPWR VPWR _1604_ sky130_fd_sc_hd__mux2_1
X_3244_ net501 _1126_ _1567_ VGND VGND VPWR VPWR _1568_ sky130_fd_sc_hd__mux2_1
XFILLER_0_67_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_83_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3175_ _1464_ VGND VGND VPWR VPWR _1531_ sky130_fd_sc_hd__buf_4
X_2126_ _0825_ net48 _0806_ VGND VGND VPWR VPWR _0826_ sky130_fd_sc_hd__mux2_1
X_2057_ _0780_ VGND VGND VPWR VPWR net124 sky130_fd_sc_hd__buf_1
XFILLER_0_49_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_80_957 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_8_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_17_411 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_91_369 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2959_ _1383_ VGND VGND VPWR VPWR _1417_ sky130_fd_sc_hd__buf_4
XFILLER_0_17_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4629_ clknet_leaf_52_clk _0669_ VGND VGND VPWR VPWR instance_2.data\[3\]\[21\] sky130_fd_sc_hd__dfxtp_1
Xhold540 instance_1.data\[2\]\[56\] VGND VGND VPWR VPWR net690 sky130_fd_sc_hd__dlygate4sd3_1
Xhold551 instance_1.data\[2\]\[71\] VGND VGND VPWR VPWR net701 sky130_fd_sc_hd__dlygate4sd3_1
Xhold562 instance_2.data\[3\]\[57\] VGND VGND VPWR VPWR net712 sky130_fd_sc_hd__dlygate4sd3_1
Xhold595 instance_1.data\[0\]\[54\] VGND VGND VPWR VPWR net745 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_12_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold573 instance_2.data\[0\]\[25\] VGND VGND VPWR VPWR net723 sky130_fd_sc_hd__dlygate4sd3_1
Xhold584 instance_2.data\[0\]\[65\] VGND VGND VPWR VPWR net734 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_43_604 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_82_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_15_339 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_12_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_51_681 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_10_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_91_1065 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xoutput82 net82 VGND VGND VPWR VPWR rdata[14] sky130_fd_sc_hd__clkbuf_4
XFILLER_0_37_24 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput93 net93 VGND VGND VPWR VPWR rdata[24] sky130_fd_sc_hd__clkbuf_4
XFILLER_0_37_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_58_322 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_46_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3931_ net696 _1009_ _1920_ VGND VGND VPWR VPWR _1929_ sky130_fd_sc_hd__mux2_1
X_3862_ net296 _0897_ _1887_ VGND VGND VPWR VPWR _1893_ sky130_fd_sc_hd__mux2_1
X_2813_ net569 _0925_ _1336_ VGND VGND VPWR VPWR _1340_ sky130_fd_sc_hd__mux2_1
XFILLER_0_26_230 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_5_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3793_ net207 _1280_ _1850_ VGND VGND VPWR VPWR _1856_ sky130_fd_sc_hd__mux2_1
XFILLER_0_81_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2744_ net351 _0807_ _1303_ VGND VGND VPWR VPWR _1304_ sky130_fd_sc_hd__mux2_1
X_2675_ net332 _1250_ _1230_ VGND VGND VPWR VPWR _1251_ sky130_fd_sc_hd__mux2_1
XFILLER_0_41_266 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_1_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4414_ clknet_leaf_40_clk _0454_ VGND VGND VPWR VPWR instance_1.data\[2\]\[22\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_78_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4345_ clknet_leaf_39_clk _0385_ VGND VGND VPWR VPWR instance_1.rdata\[25\] sky130_fd_sc_hd__dfxtp_1
X_4276_ clknet_leaf_35_clk _0316_ VGND VGND VPWR VPWR instance_1.data\[3\]\[28\] sky130_fd_sc_hd__dfxtp_1
X_3227_ net868 _1100_ _1556_ VGND VGND VPWR VPWR _1559_ sky130_fd_sc_hd__mux2_1
X_3158_ _1522_ VGND VGND VPWR VPWR _0339_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_27_90 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2109_ _0812_ VGND VGND VPWR VPWR _0813_ sky130_fd_sc_hd__buf_4
X_3089_ net577 _1124_ _1476_ VGND VGND VPWR VPWR _1486_ sky130_fd_sc_hd__mux2_1
XFILLER_0_76_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_91_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_12_309 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_37_517 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_64_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_64_358 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_17_274 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_17_263 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_20_386 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_4_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xhold370 instance_1.data\[1\]\[55\] VGND VGND VPWR VPWR net520 sky130_fd_sc_hd__dlygate4sd3_1
Xhold381 instance_1.data\[0\]\[58\] VGND VGND VPWR VPWR net531 sky130_fd_sc_hd__dlygate4sd3_1
Xhold392 instance_2.data\[0\]\[37\] VGND VGND VPWR VPWR net542 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_28_464 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_23_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_82_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_82_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_55_369 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2460_ _1084_ VGND VGND VPWR VPWR _0079_ sky130_fd_sc_hd__clkbuf_1
X_4130_ clknet_leaf_38_clk _0170_ VGND VGND VPWR VPWR instance_2.data\[1\]\[26\] sky130_fd_sc_hd__dfxtp_1
X_2391_ net338 _1030_ _1017_ VGND VGND VPWR VPWR _1031_ sky130_fd_sc_hd__mux2_1
XPHY_EDGE_ROW_79_Left_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4061_ clknet_leaf_35_clk _0101_ VGND VGND VPWR VPWR instance_1.data\[1\]\[29\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_3_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3012_ _0999_ net309 _1439_ VGND VGND VPWR VPWR _1445_ sky130_fd_sc_hd__mux2_1
XFILLER_0_58_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_80_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3914_ _1864_ VGND VGND VPWR VPWR _1920_ sky130_fd_sc_hd__buf_4
XPHY_EDGE_ROW_88_Left_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_62_787 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_73_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_6_444 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3845_ net244 _0870_ _1876_ VGND VGND VPWR VPWR _1884_ sky130_fd_sc_hd__mux2_1
X_3776_ net514 _1253_ _1839_ VGND VGND VPWR VPWR _1847_ sky130_fd_sc_hd__mux2_1
X_2727_ _1290_ VGND VGND VPWR VPWR _0140_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_73_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2658_ net185 _1237_ _1230_ VGND VGND VPWR VPWR _1238_ sky130_fd_sc_hd__mux2_1
X_2589_ instance_1.data\[0\]\[37\] instance_1.data\[1\]\[37\] instance_1.data\[2\]\[37\]
+ instance_1.data\[3\]\[37\] _1177_ _1156_ VGND VGND VPWR VPWR _1184_ sky130_fd_sc_hd__mux4_1
X_4328_ clknet_leaf_56_clk _0368_ VGND VGND VPWR VPWR instance_1.rdata\[8\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_10_494 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4259_ clknet_leaf_48_clk _0299_ VGND VGND VPWR VPWR instance_1.data\[3\]\[11\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_25_434 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_92_464 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_52_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_60_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_18_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_87_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_87_258 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1960_ _0729_ VGND VGND VPWR VPWR net143 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_7_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3630_ _1300_ VGND VGND VPWR VPWR _1770_ sky130_fd_sc_hd__buf_4
X_3561_ _0903_ net818 _1726_ VGND VGND VPWR VPWR _1734_ sky130_fd_sc_hd__mux2_1
XFILLER_0_51_350 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_3_458 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2512_ net349 _1124_ _1094_ VGND VGND VPWR VPWR _1125_ sky130_fd_sc_hd__mux2_1
XFILLER_0_11_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3492_ net588 _1283_ _1691_ VGND VGND VPWR VPWR _1698_ sky130_fd_sc_hd__mux2_1
XFILLER_0_11_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2443_ _1071_ VGND VGND VPWR VPWR _0075_ sky130_fd_sc_hd__clkbuf_1
X_2374_ net560 _1016_ _1017_ VGND VGND VPWR VPWR _1018_ sky130_fd_sc_hd__mux2_1
XFILLER_0_75_32 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4113_ clknet_leaf_52_clk _0153_ VGND VGND VPWR VPWR instance_2.data\[1\]\[9\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_45_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_67_835 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_4044_ clknet_leaf_45_clk _0084_ VGND VGND VPWR VPWR instance_1.data\[1\]\[12\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_86_291 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_22_404 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3828_ net386 _0843_ _1865_ VGND VGND VPWR VPWR _1875_ sky130_fd_sc_hd__mux2_1
XFILLER_0_6_296 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_27_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_30_481 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_61_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3759_ net681 _1226_ _1828_ VGND VGND VPWR VPWR _1838_ sky130_fd_sc_hd__mux2_1
XFILLER_0_30_545 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_37_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_65_420 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_92_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_20_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_21_534 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_88_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_88_1037 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2090_ _0797_ VGND VGND VPWR VPWR net141 sky130_fd_sc_hd__buf_1
XTAP_TAPCELL_ROW_64_805 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_88_545 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_0_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_72_882 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2992_ _1434_ VGND VGND VPWR VPWR _0261_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_71_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_16_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_28_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_43_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4662_ clknet_leaf_8_clk _0702_ VGND VGND VPWR VPWR instance_2.data\[3\]\[54\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_9_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3613_ _1761_ VGND VGND VPWR VPWR _0555_ sky130_fd_sc_hd__clkbuf_1
X_4593_ clknet_leaf_15_clk _0633_ VGND VGND VPWR VPWR instance_1.data\[0\]\[57\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_12_501 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_43_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_12_545 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3544_ _0875_ net436 _1715_ VGND VGND VPWR VPWR _1725_ sky130_fd_sc_hd__mux2_1
X_3475_ net589 _1256_ _1680_ VGND VGND VPWR VPWR _1689_ sky130_fd_sc_hd__mux2_1
X_2426_ _0720_ net76 VGND VGND VPWR VPWR _1058_ sky130_fd_sc_hd__nor2b_4
XFILLER_0_86_97 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2357_ net2 VGND VGND VPWR VPWR _1004_ sky130_fd_sc_hd__clkbuf_4
X_2288_ instance_2.data\[0\]\[41\] instance_2.data\[1\]\[41\] instance_2.data\[2\]\[41\]
+ instance_2.data\[3\]\[41\] _0923_ _0936_ VGND VGND VPWR VPWR _0951_ sky130_fd_sc_hd__mux4_1
X_4027_ clknet_leaf_7_clk _0067_ VGND VGND VPWR VPWR instance_2.data\[2\]\[67\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_19_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_47_442 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_74_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_22_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_62_489 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_7_265 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_89_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_15_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_38_486 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_53_434 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_25_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_41_587 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_25_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_0_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3260_ net406 _1153_ _1567_ VGND VGND VPWR VPWR _1576_ sky130_fd_sc_hd__mux2_1
X_3191_ _1539_ VGND VGND VPWR VPWR _0355_ sky130_fd_sc_hd__clkbuf_1
X_2211_ net201 _0891_ _0881_ VGND VGND VPWR VPWR _0892_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_77_930 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2142_ instance_2.data\[0\]\[8\] instance_2.data\[1\]\[8\] instance_2.data\[2\]\[8\]
+ instance_2.data\[3\]\[8\] _0821_ _0834_ VGND VGND VPWR VPWR _0838_ sky130_fd_sc_hd__mux4_1
XFILLER_0_56_67 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2073_ instance_1.rdata\[60\] instance_2.rdata\[60\] _0788_ VGND VGND VPWR VPWR _0789_
+ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_49_665 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_72_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_91_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2975_ _1425_ VGND VGND VPWR VPWR _0253_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_71_264 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_15_Left_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4645_ clknet_leaf_24_clk _0685_ VGND VGND VPWR VPWR instance_2.data\[3\]\[37\] sky130_fd_sc_hd__dfxtp_1
X_4576_ clknet_leaf_26_clk _0616_ VGND VGND VPWR VPWR instance_1.data\[0\]\[40\] sky130_fd_sc_hd__dfxtp_1
Xhold711 instance_2.data\[0\]\[21\] VGND VGND VPWR VPWR net861 sky130_fd_sc_hd__dlygate4sd3_1
Xhold700 instance_2.data\[0\]\[22\] VGND VGND VPWR VPWR net850 sky130_fd_sc_hd__dlygate4sd3_1
X_3527_ _1716_ VGND VGND VPWR VPWR _0514_ sky130_fd_sc_hd__clkbuf_1
X_3458_ net149 VGND VGND VPWR VPWR _1680_ sky130_fd_sc_hd__buf_4
X_3389_ net331 _1117_ _1636_ VGND VGND VPWR VPWR _1644_ sky130_fd_sc_hd__mux2_1
X_2409_ instance_2.data\[0\]\[69\] instance_2.data\[1\]\[69\] instance_2.data\[2\]\[69\]
+ instance_2.data\[3\]\[69\] _1025_ _0809_ VGND VGND VPWR VPWR _1044_ sky130_fd_sc_hd__mux4_1
XTAP_TAPCELL_ROW_4_235 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_24_Left_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_39_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_83_988 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_90_551 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_33_Left_126 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_47_294 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_62_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_42_Left_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_74_900 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xhold82 instance_1.rdata\[7\] VGND VGND VPWR VPWR net232 sky130_fd_sc_hd__dlygate4sd3_1
Xhold71 instance_1.data\[3\]\[15\] VGND VGND VPWR VPWR net221 sky130_fd_sc_hd__dlygate4sd3_1
Xhold60 instance_1.data\[2\]\[19\] VGND VGND VPWR VPWR net210 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_85_1007 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xhold93 instance_1.data\[0\]\[13\] VGND VGND VPWR VPWR net243 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_46_635 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_38_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_51_Left_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2760_ net498 _0839_ _1303_ VGND VGND VPWR VPWR _1312_ sky130_fd_sc_hd__mux2_1
X_2691_ net60 _1262_ _1233_ VGND VGND VPWR VPWR _1263_ sky130_fd_sc_hd__mux2_1
X_4430_ clknet_leaf_27_clk _0470_ VGND VGND VPWR VPWR instance_1.data\[2\]\[38\] sky130_fd_sc_hd__dfxtp_1
XANTENNA_2 net68 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_41_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4361_ clknet_leaf_25_clk _0401_ VGND VGND VPWR VPWR instance_1.rdata\[41\] sky130_fd_sc_hd__dfxtp_1
X_4292_ clknet_leaf_25_clk _0332_ VGND VGND VPWR VPWR instance_1.data\[3\]\[44\] sky130_fd_sc_hd__dfxtp_1
X_3312_ _1603_ VGND VGND VPWR VPWR _0412_ sky130_fd_sc_hd__clkbuf_1
XPHY_EDGE_ROW_60_Left_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3243_ _1544_ VGND VGND VPWR VPWR _1567_ sky130_fd_sc_hd__clkbuf_4
X_3174_ _1530_ VGND VGND VPWR VPWR _0347_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_1_205 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2125_ instance_2.data\[0\]\[4\] instance_2.data\[1\]\[4\] instance_2.data\[2\]\[4\]
+ instance_2.data\[3\]\[4\] _0821_ _0804_ VGND VGND VPWR VPWR _0825_ sky130_fd_sc_hd__mux4_1
X_2056_ instance_1.rdata\[52\] instance_2.rdata\[52\] _0777_ VGND VGND VPWR VPWR _0780_
+ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_80_958 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_8_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_29_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2958_ _1416_ VGND VGND VPWR VPWR _0245_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_17_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_44_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_44_264 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_4_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4628_ clknet_leaf_52_clk _0668_ VGND VGND VPWR VPWR instance_2.data\[3\]\[20\] sky130_fd_sc_hd__dfxtp_1
X_2889_ _1379_ VGND VGND VPWR VPWR _0213_ sky130_fd_sc_hd__clkbuf_1
Xhold530 instance_2.rdata\[68\] VGND VGND VPWR VPWR net680 sky130_fd_sc_hd__dlygate4sd3_1
Xhold541 instance_1.data\[0\]\[67\] VGND VGND VPWR VPWR net691 sky130_fd_sc_hd__dlygate4sd3_1
Xhold552 instance_1.data\[3\]\[63\] VGND VGND VPWR VPWR net702 sky130_fd_sc_hd__dlygate4sd3_1
X_4559_ clknet_leaf_42_clk _0599_ VGND VGND VPWR VPWR instance_1.data\[0\]\[23\] sky130_fd_sc_hd__dfxtp_1
Xhold563 instance_1.data\[0\]\[70\] VGND VGND VPWR VPWR net713 sky130_fd_sc_hd__dlygate4sd3_1
Xhold596 instance_1.data\[2\]\[63\] VGND VGND VPWR VPWR net746 sky130_fd_sc_hd__dlygate4sd3_1
Xhold574 instance_1.data\[3\]\[62\] VGND VGND VPWR VPWR net724 sky130_fd_sc_hd__dlygate4sd3_1
Xhold585 instance_2.data\[2\]\[45\] VGND VGND VPWR VPWR net735 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_86_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_79_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_79_183 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_43_605 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_82_326 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_35_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_51_682 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_2_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_50_256 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_91_1066 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xoutput83 net83 VGND VGND VPWR VPWR rdata[15] sky130_fd_sc_hd__clkbuf_4
Xoutput94 net94 VGND VGND VPWR VPWR rdata[25] sky130_fd_sc_hd__clkbuf_4
XFILLER_0_37_36 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_37_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_59_760 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_53_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3930_ _1928_ VGND VGND VPWR VPWR _0705_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_18_209 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3861_ _1892_ VGND VGND VPWR VPWR _0672_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_46_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_73_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3792_ _1855_ VGND VGND VPWR VPWR _0640_ sky130_fd_sc_hd__clkbuf_1
X_2812_ _1339_ VGND VGND VPWR VPWR _0176_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_5_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2743_ _1302_ VGND VGND VPWR VPWR _1303_ sky130_fd_sc_hd__buf_4
X_2674_ net55 _1249_ _1233_ VGND VGND VPWR VPWR _1250_ sky130_fd_sc_hd__mux2_1
X_4413_ clknet_leaf_42_clk _0453_ VGND VGND VPWR VPWR instance_1.data\[2\]\[21\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_68_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4344_ clknet_leaf_39_clk _0384_ VGND VGND VPWR VPWR instance_1.rdata\[24\] sky130_fd_sc_hd__dfxtp_1
X_4275_ clknet_leaf_35_clk _0315_ VGND VGND VPWR VPWR instance_1.data\[3\]\[27\] sky130_fd_sc_hd__dfxtp_1
X_3226_ _1558_ VGND VGND VPWR VPWR _0371_ sky130_fd_sc_hd__clkbuf_1
X_3157_ net357 _1234_ _1520_ VGND VGND VPWR VPWR _1522_ sky130_fd_sc_hd__mux2_1
X_2108_ _0811_ VGND VGND VPWR VPWR _0812_ sky130_fd_sc_hd__buf_4
X_3088_ _1485_ VGND VGND VPWR VPWR _0306_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_49_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2039_ instance_1.rdata\[44\] instance_2.rdata\[44\] _0766_ VGND VGND VPWR VPWR _0771_
+ sky130_fd_sc_hd__mux2_1
XFILLER_0_37_529 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_76_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_91_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_20_387 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_32_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xhold371 instance_1.data\[3\]\[45\] VGND VGND VPWR VPWR net521 sky130_fd_sc_hd__dlygate4sd3_1
Xhold360 instance_1.data\[3\]\[23\] VGND VGND VPWR VPWR net510 sky130_fd_sc_hd__dlygate4sd3_1
Xhold382 instance_1.data\[0\]\[55\] VGND VGND VPWR VPWR net532 sky130_fd_sc_hd__dlygate4sd3_1
Xhold393 instance_1.data\[2\]\[23\] VGND VGND VPWR VPWR net543 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_56_730 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_28_465 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_23_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_82_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_28_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_82_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2390_ _1029_ net64 _1012_ VGND VGND VPWR VPWR _1030_ sky130_fd_sc_hd__mux2_1
XFILLER_0_3_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4060_ clknet_leaf_35_clk _0100_ VGND VGND VPWR VPWR instance_1.data\[1\]\[28\] sky130_fd_sc_hd__dfxtp_1
X_3011_ _1444_ VGND VGND VPWR VPWR _0270_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_64_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_86_440 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_46_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3913_ _1919_ VGND VGND VPWR VPWR _0697_ sky130_fd_sc_hd__clkbuf_1
X_3844_ _1883_ VGND VGND VPWR VPWR _0664_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_6_401 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_58_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_62_788 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3775_ _1846_ VGND VGND VPWR VPWR _0632_ sky130_fd_sc_hd__clkbuf_1
X_2726_ net168 _1289_ _1264_ VGND VGND VPWR VPWR _1290_ sky130_fd_sc_hd__mux2_1
X_2657_ net51 _1236_ _1233_ VGND VGND VPWR VPWR _1237_ sky130_fd_sc_hd__mux2_1
XFILLER_0_1_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2588_ _1183_ VGND VGND VPWR VPWR _0108_ sky130_fd_sc_hd__clkbuf_1
X_4327_ clknet_leaf_57_clk _0367_ VGND VGND VPWR VPWR instance_1.rdata\[7\] sky130_fd_sc_hd__dfxtp_1
X_4258_ clknet_leaf_49_clk _0298_ VGND VGND VPWR VPWR instance_1.data\[3\]\[10\] sky130_fd_sc_hd__dfxtp_1
X_3209_ _1549_ VGND VGND VPWR VPWR _0363_ sky130_fd_sc_hd__clkbuf_1
X_4189_ clknet_leaf_46_clk _0229_ VGND VGND VPWR VPWR instance_2.data\[0\]\[13\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_53_700 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_25_435 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_92_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_37_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_49_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_18_551 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_52_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_20_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_60_395 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold190 instance_2.data\[2\]\[18\] VGND VGND VPWR VPWR net340 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_18_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_87_204 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_16_Right_16 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_55_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_25_Right_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3560_ _1733_ VGND VGND VPWR VPWR _0530_ sky130_fd_sc_hd__clkbuf_1
X_2511_ net14 _1123_ _1097_ VGND VGND VPWR VPWR _1124_ sky130_fd_sc_hd__mux2_1
X_3491_ _1697_ VGND VGND VPWR VPWR _0497_ sky130_fd_sc_hd__clkbuf_1
X_2442_ net388 _1070_ _1060_ VGND VGND VPWR VPWR _1071_ sky130_fd_sc_hd__mux2_1
X_2373_ _0812_ VGND VGND VPWR VPWR _1017_ sky130_fd_sc_hd__buf_4
X_4112_ clknet_leaf_56_clk _0152_ VGND VGND VPWR VPWR instance_2.data\[1\]\[8\] sky130_fd_sc_hd__dfxtp_1
X_4043_ clknet_leaf_48_clk _0083_ VGND VGND VPWR VPWR instance_1.data\[1\]\[11\] sky130_fd_sc_hd__dfxtp_1
XPHY_EDGE_ROW_34_Right_34 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_67_836 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_59_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_74_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_22_405 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_6_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3827_ _1874_ VGND VGND VPWR VPWR _0656_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_34_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_43_Right_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_61_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3758_ _1837_ VGND VGND VPWR VPWR _0624_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_30_482 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2709_ net64 _1276_ _1267_ VGND VGND VPWR VPWR _1277_ sky130_fd_sc_hd__mux2_1
X_3689_ _1801_ VGND VGND VPWR VPWR _0591_ sky130_fd_sc_hd__clkbuf_1
XPHY_EDGE_ROW_52_Right_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_38_560 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_77_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_77_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_61_Right_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_37_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_0_418 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_60_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_70_Right_70 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_88_1038 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_88_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_64_806 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_0_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_72_883 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2991_ _0965_ net842 _1428_ VGND VGND VPWR VPWR _1434_ sky130_fd_sc_hd__mux2_1
XFILLER_0_61_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4661_ clknet_leaf_12_clk _0701_ VGND VGND VPWR VPWR instance_2.data\[3\]\[53\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_9_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3612_ _0985_ net451 _1759_ VGND VGND VPWR VPWR _1761_ sky130_fd_sc_hd__mux2_1
X_4592_ clknet_leaf_15_clk _0632_ VGND VGND VPWR VPWR instance_1.data\[0\]\[56\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_12_513 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_3_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_3_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3543_ _1724_ VGND VGND VPWR VPWR _0522_ sky130_fd_sc_hd__clkbuf_1
X_3474_ _1688_ VGND VGND VPWR VPWR _0489_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_10_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2425_ net2 net1 VGND VGND VPWR VPWR _1057_ sky130_fd_sc_hd__or2b_2
X_2356_ _1003_ VGND VGND VPWR VPWR _0056_ sky130_fd_sc_hd__clkbuf_1
X_2287_ _0950_ VGND VGND VPWR VPWR _0040_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_29_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4026_ clknet_leaf_3_clk _0066_ VGND VGND VPWR VPWR instance_2.data\[2\]\[66\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_35_530 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_47_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_59_292 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_551 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_3_0__f_clk clknet_0_clk VGND VGND VPWR VPWR clknet_3_0__leaf_clk sky130_fd_sc_hd__clkbuf_16
XFILLER_0_30_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_30_376 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_7_266 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_15_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_41_588 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_21_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_21_387 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2210_ _0890_ net19 _0876_ VGND VGND VPWR VPWR _0891_ sky130_fd_sc_hd__mux2_1
X_3190_ net320 _1286_ _1531_ VGND VGND VPWR VPWR _1539_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_77_931 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2141_ _0837_ VGND VGND VPWR VPWR _0007_ sky130_fd_sc_hd__clkbuf_1
X_2072_ _0721_ VGND VGND VPWR VPWR _0788_ sky130_fd_sc_hd__clkbuf_4
XTAP_TAPCELL_ROW_49_666 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_88_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_76_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_29_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_32_500 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2974_ _0938_ net542 _1417_ VGND VGND VPWR VPWR _1425_ sky130_fd_sc_hd__mux2_1
XFILLER_0_16_115 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_56_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_16_126 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4644_ clknet_leaf_29_clk _0684_ VGND VGND VPWR VPWR instance_2.data\[3\]\[36\] sky130_fd_sc_hd__dfxtp_1
X_4575_ clknet_leaf_28_clk _0615_ VGND VGND VPWR VPWR instance_1.data\[0\]\[39\] sky130_fd_sc_hd__dfxtp_1
Xhold712 instance_2.rdata\[17\] VGND VGND VPWR VPWR net862 sky130_fd_sc_hd__dlygate4sd3_1
Xhold701 instance_2.rdata\[29\] VGND VGND VPWR VPWR net851 sky130_fd_sc_hd__dlygate4sd3_1
X_3526_ _0845_ net815 _1715_ VGND VGND VPWR VPWR _1716_ sky130_fd_sc_hd__mux2_1
XFILLER_0_12_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3457_ _1679_ VGND VGND VPWR VPWR _0481_ sky130_fd_sc_hd__clkbuf_1
X_3388_ _1643_ VGND VGND VPWR VPWR _0448_ sky130_fd_sc_hd__clkbuf_1
X_2408_ _1043_ VGND VGND VPWR VPWR _0068_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_4_236 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2339_ _0990_ VGND VGND VPWR VPWR _0052_ sky130_fd_sc_hd__clkbuf_1
XPHY_EDGE_ROW_2_Right_2 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4009_ clknet_leaf_7_clk _0049_ VGND VGND VPWR VPWR instance_2.data\[2\]\[49\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_67_505 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_83_989 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_35_402 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_50_416 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_62_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xhold50 instance_1.data\[0\]\[0\] VGND VGND VPWR VPWR net200 sky130_fd_sc_hd__dlygate4sd3_1
Xhold72 instance_1.data\[1\]\[45\] VGND VGND VPWR VPWR net222 sky130_fd_sc_hd__dlygate4sd3_1
Xhold61 instance_2.data\[1\]\[17\] VGND VGND VPWR VPWR net211 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_26_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold83 instance_2.data\[1\]\[30\] VGND VGND VPWR VPWR net233 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_85_1008 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_74_901 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xhold94 instance_2.data\[3\]\[17\] VGND VGND VPWR VPWR net244 sky130_fd_sc_hd__dlygate4sd3_1
Xclkbuf_leaf_55_clk clknet_3_1__leaf_clk VGND VGND VPWR VPWR clknet_leaf_55_clk sky130_fd_sc_hd__clkbuf_8
XTAP_TAPCELL_ROW_46_636 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_85_346 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_26_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_38_262 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_5_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_5_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_53_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2690_ instance_1.data\[0\]\[60\] instance_1.data\[1\]\[60\] instance_1.data\[2\]\[60\]
+ instance_1.data\[3\]\[60\] _1245_ _1258_ VGND VGND VPWR VPWR _1262_ sky130_fd_sc_hd__mux4_1
XFILLER_0_41_405 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_3 net89 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_4360_ clknet_leaf_25_clk _0400_ VGND VGND VPWR VPWR instance_1.rdata\[40\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_6_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3311_ net191 _1236_ _1600_ VGND VGND VPWR VPWR _1603_ sky130_fd_sc_hd__mux2_1
X_4291_ clknet_leaf_26_clk _0331_ VGND VGND VPWR VPWR instance_1.data\[3\]\[43\] sky130_fd_sc_hd__dfxtp_1
X_3242_ _1566_ VGND VGND VPWR VPWR _0379_ sky130_fd_sc_hd__clkbuf_1
X_3173_ net663 _1260_ _1520_ VGND VGND VPWR VPWR _1530_ sky130_fd_sc_hd__mux2_1
X_2124_ _0824_ VGND VGND VPWR VPWR _0003_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_1_206 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_leaf_46_clk clknet_3_5__leaf_clk VGND VGND VPWR VPWR clknet_leaf_46_clk sky130_fd_sc_hd__clkbuf_8
X_2055_ _0779_ VGND VGND VPWR VPWR net123 sky130_fd_sc_hd__buf_1
XFILLER_0_88_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_16_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_80_959 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_17_360 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_91_305 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_435 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_32_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2957_ _0911_ net849 _1406_ VGND VGND VPWR VPWR _1416_ sky130_fd_sc_hd__mux2_1
X_2888_ net621 _1046_ _1369_ VGND VGND VPWR VPWR _1379_ sky130_fd_sc_hd__mux2_1
X_4627_ clknet_leaf_52_clk _0667_ VGND VGND VPWR VPWR instance_2.data\[3\]\[19\] sky130_fd_sc_hd__dfxtp_1
Xhold520 instance_1.data\[2\]\[68\] VGND VGND VPWR VPWR net670 sky130_fd_sc_hd__dlygate4sd3_1
Xhold553 instance_1.data\[2\]\[45\] VGND VGND VPWR VPWR net703 sky130_fd_sc_hd__dlygate4sd3_1
Xhold531 instance_1.data\[0\]\[49\] VGND VGND VPWR VPWR net681 sky130_fd_sc_hd__dlygate4sd3_1
Xhold542 instance_1.rdata\[57\] VGND VGND VPWR VPWR net692 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_4_395 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4558_ clknet_leaf_42_clk _0598_ VGND VGND VPWR VPWR instance_1.data\[0\]\[22\] sky130_fd_sc_hd__dfxtp_1
X_3509_ _0818_ net739 _1704_ VGND VGND VPWR VPWR _1707_ sky130_fd_sc_hd__mux2_1
Xhold575 instance_2.rdata\[4\] VGND VGND VPWR VPWR net725 sky130_fd_sc_hd__dlygate4sd3_1
Xhold564 instance_1.data\[1\]\[65\] VGND VGND VPWR VPWR net714 sky130_fd_sc_hd__dlygate4sd3_1
X_4489_ clknet_leaf_39_clk _0529_ VGND VGND VPWR VPWR instance_2.rdata\[25\] sky130_fd_sc_hd__dfxtp_1
Xhold597 instance_2.rdata\[25\] VGND VGND VPWR VPWR net747 sky130_fd_sc_hd__dlygate4sd3_1
Xhold586 instance_2.data\[3\]\[41\] VGND VGND VPWR VPWR net736 sky130_fd_sc_hd__dlygate4sd3_1
Xclkbuf_leaf_37_clk clknet_3_6__leaf_clk VGND VGND VPWR VPWR clknet_leaf_37_clk sky130_fd_sc_hd__clkbuf_8
XTAP_TAPCELL_ROW_43_606 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_67_346 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_12_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_51_683 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_23_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_50_268 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_91_1067 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xoutput84 net84 VGND VGND VPWR VPWR rdata[16] sky130_fd_sc_hd__clkbuf_4
XFILLER_0_37_48 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xoutput95 net95 VGND VGND VPWR VPWR rdata[26] sky130_fd_sc_hd__buf_2
XTAP_TAPCELL_ROW_59_761 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_leaf_28_clk clknet_3_6__leaf_clk VGND VGND VPWR VPWR clknet_leaf_28_clk sky130_fd_sc_hd__clkbuf_8
XTAP_TAPCELL_ROW_14_330 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_3860_ net321 _0894_ _1887_ VGND VGND VPWR VPWR _1892_ sky130_fd_sc_hd__mux2_1
X_3791_ net579 _1277_ _1850_ VGND VGND VPWR VPWR _1855_ sky130_fd_sc_hd__mux2_1
XFILLER_0_54_530 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2811_ net630 _0921_ _1336_ VGND VGND VPWR VPWR _1339_ sky130_fd_sc_hd__mux2_1
X_2742_ _1301_ VGND VGND VPWR VPWR _1302_ sky130_fd_sc_hd__buf_4
XFILLER_0_81_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_26_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2673_ instance_1.data\[0\]\[56\] instance_1.data\[1\]\[56\] instance_1.data\[2\]\[56\]
+ instance_1.data\[3\]\[56\] _1245_ _1224_ VGND VGND VPWR VPWR _1249_ sky130_fd_sc_hd__mux4_1
X_4412_ clknet_leaf_40_clk _0452_ VGND VGND VPWR VPWR instance_1.data\[2\]\[20\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_22_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4343_ clknet_leaf_39_clk _0383_ VGND VGND VPWR VPWR instance_1.rdata\[23\] sky130_fd_sc_hd__dfxtp_1
X_4274_ clknet_leaf_41_clk _0314_ VGND VGND VPWR VPWR instance_1.data\[3\]\[26\] sky130_fd_sc_hd__dfxtp_1
X_3225_ net704 _1096_ _1556_ VGND VGND VPWR VPWR _1558_ sky130_fd_sc_hd__mux2_1
X_3156_ _1521_ VGND VGND VPWR VPWR _0338_ sky130_fd_sc_hd__clkbuf_1
Xclkbuf_leaf_19_clk clknet_3_3__leaf_clk VGND VGND VPWR VPWR clknet_leaf_19_clk sky130_fd_sc_hd__clkbuf_8
X_3087_ net454 _1120_ _1476_ VGND VGND VPWR VPWR _1485_ sky130_fd_sc_hd__mux2_1
X_2107_ _0808_ _0809_ _0810_ VGND VGND VPWR VPWR _0811_ sky130_fd_sc_hd__and3b_1
X_2038_ _0770_ VGND VGND VPWR VPWR net114 sky130_fd_sc_hd__buf_1
XFILLER_0_11_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_49_324 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_64_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_91_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_45_541 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3989_ clknet_leaf_37_clk _0029_ VGND VGND VPWR VPWR instance_2.data\[2\]\[29\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_32_224 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_20_388 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xhold361 instance_1.rdata\[50\] VGND VGND VPWR VPWR net511 sky130_fd_sc_hd__dlygate4sd3_1
Xhold350 instance_1.data\[3\]\[31\] VGND VGND VPWR VPWR net500 sky130_fd_sc_hd__dlygate4sd3_1
Xhold372 instance_2.data\[0\]\[38\] VGND VGND VPWR VPWR net522 sky130_fd_sc_hd__dlygate4sd3_1
Xhold383 instance_2.rdata\[13\] VGND VGND VPWR VPWR net533 sky130_fd_sc_hd__dlygate4sd3_1
Xhold394 instance_2.data\[1\]\[31\] VGND VGND VPWR VPWR net544 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_87_408 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_56_731 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_28_466 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_67_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_23_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_82_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_55_327 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_11_300 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_23_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_63_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_48_14 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_3_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_3010_ _0996_ net598 _1439_ VGND VGND VPWR VPWR _1444_ sky130_fd_sc_hd__mux2_1
XFILLER_0_64_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_78_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3912_ net323 _0979_ _1909_ VGND VGND VPWR VPWR _1919_ sky130_fd_sc_hd__mux2_1
XFILLER_0_73_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3843_ net230 _0866_ _1876_ VGND VGND VPWR VPWR _1883_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_62_789 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_13_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_6_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_27_541 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3774_ net420 _1250_ _1839_ VGND VGND VPWR VPWR _1846_ sky130_fd_sc_hd__mux2_1
X_2725_ net68 _1288_ _1267_ VGND VGND VPWR VPWR _1289_ sky130_fd_sc_hd__mux2_1
XFILLER_0_42_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2656_ instance_1.data\[0\]\[52\] instance_1.data\[1\]\[52\] instance_1.data\[2\]\[52\]
+ instance_1.data\[3\]\[52\] _1211_ _1224_ VGND VGND VPWR VPWR _1236_ sky130_fd_sc_hd__mux4_1
Xclkbuf_leaf_8_clk clknet_3_2__leaf_clk VGND VGND VPWR VPWR clknet_leaf_8_clk sky130_fd_sc_hd__clkbuf_8
X_2587_ net699 _1182_ _1162_ VGND VGND VPWR VPWR _1183_ sky130_fd_sc_hd__mux2_1
XFILLER_0_10_452 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_59_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4326_ clknet_leaf_58_clk _0366_ VGND VGND VPWR VPWR instance_1.rdata\[6\] sky130_fd_sc_hd__dfxtp_1
X_4257_ clknet_leaf_57_clk _0297_ VGND VGND VPWR VPWR instance_1.data\[3\]\[9\] sky130_fd_sc_hd__dfxtp_1
X_3208_ net731 _1069_ _1545_ VGND VGND VPWR VPWR _1549_ sky130_fd_sc_hd__mux2_1
X_4188_ clknet_leaf_49_clk _0228_ VGND VGND VPWR VPWR instance_2.data\[0\]\[12\] sky130_fd_sc_hd__dfxtp_1
X_3139_ _1512_ VGND VGND VPWR VPWR _0330_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_53_701 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_25_436 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_92_477 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_18_530 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_13_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xhold180 instance_2.data\[2\]\[46\] VGND VGND VPWR VPWR net330 sky130_fd_sc_hd__dlygate4sd3_1
Xhold191 instance_1.data\[2\]\[55\] VGND VGND VPWR VPWR net341 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_0_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2510_ instance_1.data\[0\]\[19\] instance_1.data\[1\]\[19\] instance_1.data\[2\]\[19\]
+ instance_1.data\[3\]\[19\] _1109_ _1122_ VGND VGND VPWR VPWR _1123_ sky130_fd_sc_hd__mux4_1
X_3490_ net648 _1280_ _1691_ VGND VGND VPWR VPWR _1697_ sky130_fd_sc_hd__mux2_1
XFILLER_0_51_374 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2441_ net37 _1069_ _1063_ VGND VGND VPWR VPWR _1070_ sky130_fd_sc_hd__mux2_1
XFILLER_0_59_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2372_ _1015_ net60 _1012_ VGND VGND VPWR VPWR _1016_ sky130_fd_sc_hd__mux2_1
X_4111_ clknet_leaf_56_clk _0151_ VGND VGND VPWR VPWR instance_2.data\[1\]\[7\] sky130_fd_sc_hd__dfxtp_1
X_4042_ clknet_leaf_48_clk _0082_ VGND VGND VPWR VPWR instance_1.data\[1\]\[10\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_67_837 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_91_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_22_406 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_74_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3826_ net421 _0839_ _1865_ VGND VGND VPWR VPWR _1874_ sky130_fd_sc_hd__mux2_1
X_3757_ net228 _1222_ _1828_ VGND VGND VPWR VPWR _1837_ sky130_fd_sc_hd__mux2_1
XFILLER_0_27_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_30_483 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2708_ instance_1.data\[0\]\[64\] instance_1.data\[1\]\[64\] instance_1.data\[2\]\[64\]
+ instance_1.data\[3\]\[64\] _1245_ _1258_ VGND VGND VPWR VPWR _1276_ sky130_fd_sc_hd__mux4_1
XFILLER_0_42_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3688_ net502 _1111_ _1795_ VGND VGND VPWR VPWR _1801_ sky130_fd_sc_hd__mux2_1
X_2639_ net685 _1222_ _1196_ VGND VGND VPWR VPWR _1223_ sky130_fd_sc_hd__mux2_1
X_4309_ clknet_leaf_1_clk _0349_ VGND VGND VPWR VPWR instance_1.data\[3\]\[61\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_38_561 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_20_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_33_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_45_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_21_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_33_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_33_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_88_1039 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_88_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_64_807 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_72_884 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2990_ _1433_ VGND VGND VPWR VPWR _0260_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_28_157 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_56_466 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4660_ clknet_leaf_8_clk _0700_ VGND VGND VPWR VPWR instance_2.data\[3\]\[52\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_71_458 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_71_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3611_ _1760_ VGND VGND VPWR VPWR _0554_ sky130_fd_sc_hd__clkbuf_1
X_4591_ clknet_leaf_15_clk _0631_ VGND VGND VPWR VPWR instance_1.data\[0\]\[55\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_12_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3542_ _0872_ net866 _1715_ VGND VGND VPWR VPWR _1724_ sky130_fd_sc_hd__mux2_1
X_3473_ net314 _1253_ _1680_ VGND VGND VPWR VPWR _1688_ sky130_fd_sc_hd__mux2_1
X_2424_ net4 _1055_ _0721_ VGND VGND VPWR VPWR _1056_ sky130_fd_sc_hd__mux2_1
X_2355_ net478 _1002_ _0983_ VGND VGND VPWR VPWR _1003_ sky130_fd_sc_hd__mux2_1
X_2286_ net343 _0948_ _0949_ VGND VGND VPWR VPWR _0950_ sky130_fd_sc_hd__mux2_1
X_4025_ clknet_leaf_9_clk _0065_ VGND VGND VPWR VPWR instance_2.data\[2\]\[65\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_35_531 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_19_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_47_466 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_74_285 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3809_ _1864_ VGND VGND VPWR VPWR _1865_ sky130_fd_sc_hd__buf_4
XFILLER_0_15_374 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_7_267 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_41_589 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_80_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_18_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_33_182 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_0_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_0_238 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_77_932 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2140_ net372 _0836_ _0813_ VGND VGND VPWR VPWR _0837_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_49_667 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2071_ _0787_ VGND VGND VPWR VPWR net131 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_88_377 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2973_ _1424_ VGND VGND VPWR VPWR _0252_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_29_444 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_32_501 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_71_200 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_71_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_16_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_4_533 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4643_ clknet_leaf_32_clk _0683_ VGND VGND VPWR VPWR instance_2.data\[3\]\[35\] sky130_fd_sc_hd__dfxtp_1
X_4574_ clknet_leaf_27_clk _0614_ VGND VGND VPWR VPWR instance_1.data\[0\]\[38\] sky130_fd_sc_hd__dfxtp_1
Xhold702 instance_1.data\[3\]\[54\] VGND VGND VPWR VPWR net852 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_12_355 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_3525_ _1300_ VGND VGND VPWR VPWR _1715_ sky130_fd_sc_hd__buf_4
Xhold713 instance_2.rdata\[21\] VGND VGND VPWR VPWR net863 sky130_fd_sc_hd__dlygate4sd3_1
X_3456_ net442 _1226_ _1669_ VGND VGND VPWR VPWR _1679_ sky130_fd_sc_hd__mux2_1
X_3387_ net422 _1114_ _1636_ VGND VGND VPWR VPWR _1643_ sky130_fd_sc_hd__mux2_1
X_2407_ net604 _1042_ _1017_ VGND VGND VPWR VPWR _1043_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_4_237 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2338_ net597 _0989_ _0983_ VGND VGND VPWR VPWR _0990_ sky130_fd_sc_hd__mux2_1
X_2269_ net2 VGND VGND VPWR VPWR _0936_ sky130_fd_sc_hd__clkbuf_4
X_4008_ clknet_leaf_20_clk _0048_ VGND VGND VPWR VPWR instance_2.data\[2\]\[48\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_67_517 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_90_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_47_285 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_7_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xhold40 instance_1.data\[2\]\[41\] VGND VGND VPWR VPWR net190 sky130_fd_sc_hd__dlygate4sd3_1
Xhold73 instance_1.data\[0\]\[41\] VGND VGND VPWR VPWR net223 sky130_fd_sc_hd__dlygate4sd3_1
Xhold62 instance_1.data\[2\]\[46\] VGND VGND VPWR VPWR net212 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_26_17 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xhold51 instance_2.data\[2\]\[23\] VGND VGND VPWR VPWR net201 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_85_1009 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xhold84 instance_1.data\[3\]\[47\] VGND VGND VPWR VPWR net234 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_74_902 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xhold95 instance_1.data\[3\]\[10\] VGND VGND VPWR VPWR net245 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_46_637 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_42_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_26_425 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_38_296 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_53_244 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_41_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_4 net93 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_3310_ _1602_ VGND VGND VPWR VPWR _0411_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_6_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_4290_ clknet_leaf_27_clk _0330_ VGND VGND VPWR VPWR instance_1.data\[3\]\[42\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_67_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_3241_ net504 _1123_ _1556_ VGND VGND VPWR VPWR _1566_ sky130_fd_sc_hd__mux2_1
X_3172_ _1529_ VGND VGND VPWR VPWR _0346_ sky130_fd_sc_hd__clkbuf_1
X_2123_ net363 _0823_ _0813_ VGND VGND VPWR VPWR _0824_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_1_207 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_88_141 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2054_ instance_1.rdata\[51\] instance_2.rdata\[51\] _0777_ VGND VGND VPWR VPWR _0779_
+ sky130_fd_sc_hd__mux2_1
XFILLER_0_16_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_17_361 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_91_317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_29_263 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_57_550 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_44_211 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2956_ _1415_ VGND VGND VPWR VPWR _0244_ sky130_fd_sc_hd__clkbuf_1
X_2887_ _1378_ VGND VGND VPWR VPWR _0212_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_89_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_4626_ clknet_leaf_50_clk _0666_ VGND VGND VPWR VPWR instance_2.data\[3\]\[18\] sky130_fd_sc_hd__dfxtp_1
Xhold510 instance_2.data\[1\]\[21\] VGND VGND VPWR VPWR net660 sky130_fd_sc_hd__dlygate4sd3_1
Xhold554 instance_1.rdata\[11\] VGND VGND VPWR VPWR net704 sky130_fd_sc_hd__dlygate4sd3_1
X_4557_ clknet_leaf_42_clk _0597_ VGND VGND VPWR VPWR instance_1.data\[0\]\[21\] sky130_fd_sc_hd__dfxtp_1
Xhold521 instance_2.data\[2\]\[28\] VGND VGND VPWR VPWR net671 sky130_fd_sc_hd__dlygate4sd3_1
Xhold532 instance_1.rdata\[29\] VGND VGND VPWR VPWR net682 sky130_fd_sc_hd__dlygate4sd3_1
Xhold543 instance_2.data\[3\]\[51\] VGND VGND VPWR VPWR net693 sky130_fd_sc_hd__dlygate4sd3_1
X_3508_ _1706_ VGND VGND VPWR VPWR _0505_ sky130_fd_sc_hd__clkbuf_1
Xhold565 instance_1.data\[1\]\[10\] VGND VGND VPWR VPWR net715 sky130_fd_sc_hd__dlygate4sd3_1
Xhold576 instance_1.data\[0\]\[61\] VGND VGND VPWR VPWR net726 sky130_fd_sc_hd__dlygate4sd3_1
X_4488_ clknet_leaf_39_clk _0528_ VGND VGND VPWR VPWR instance_2.rdata\[24\] sky130_fd_sc_hd__dfxtp_1
Xhold587 instance_2.data\[0\]\[57\] VGND VGND VPWR VPWR net737 sky130_fd_sc_hd__dlygate4sd3_1
X_3439_ _1670_ VGND VGND VPWR VPWR _0472_ sky130_fd_sc_hd__clkbuf_1
Xhold598 instance_2.data\[3\]\[40\] VGND VGND VPWR VPWR net748 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_79_130 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_43_607 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_51_684 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_91_1068 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xoutput85 net85 VGND VGND VPWR VPWR rdata[17] sky130_fd_sc_hd__clkbuf_4
Xoutput96 net96 VGND VGND VPWR VPWR rdata[27] sky130_fd_sc_hd__clkbuf_4
XTAP_TAPCELL_ROW_59_762 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_85_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_73_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_14_331 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_85_199 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3790_ _1854_ VGND VGND VPWR VPWR _0639_ sky130_fd_sc_hd__clkbuf_1
X_2810_ _1338_ VGND VGND VPWR VPWR _0175_ sky130_fd_sc_hd__clkbuf_1
X_2741_ _1057_ _1300_ VGND VGND VPWR VPWR _1301_ sky130_fd_sc_hd__and2b_1
XFILLER_0_81_361 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2672_ _1248_ VGND VGND VPWR VPWR _0127_ sky130_fd_sc_hd__clkbuf_1
X_4411_ clknet_leaf_40_clk _0451_ VGND VGND VPWR VPWR instance_1.data\[2\]\[19\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_41_225 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_75_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_4342_ clknet_leaf_39_clk _0382_ VGND VGND VPWR VPWR instance_1.rdata\[22\] sky130_fd_sc_hd__dfxtp_1
X_4273_ clknet_leaf_41_clk _0313_ VGND VGND VPWR VPWR instance_1.data\[3\]\[25\] sky130_fd_sc_hd__dfxtp_1
X_3224_ _1557_ VGND VGND VPWR VPWR _0370_ sky130_fd_sc_hd__clkbuf_1
.ends
