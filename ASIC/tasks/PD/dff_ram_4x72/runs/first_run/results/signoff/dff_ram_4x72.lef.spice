* NGSPICE file created from dff_ram_4x72.ext - technology: sky130A

* Black-box entry subcircuit for sky130_fd_sc_hd__dfxtp_1 abstract view
.subckt sky130_fd_sc_hd__dfxtp_1 CLK D VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_6 abstract view
.subckt sky130_fd_sc_hd__decap_6 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dlygate4sd3_1 abstract view
.subckt sky130_fd_sc_hd__dlygate4sd3_1 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_3 abstract view
.subckt sky130_fd_sc_hd__decap_3 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_8 abstract view
.subckt sky130_fd_sc_hd__decap_8 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_ef_sc_hd__decap_12 abstract view
.subckt sky130_ef_sc_hd__decap_12 VPWR VGND VPB VNB
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__tapvpwrvgnd_1 abstract view
.subckt sky130_fd_sc_hd__tapvpwrvgnd_1 VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_4 abstract view
.subckt sky130_fd_sc_hd__decap_4 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__mux2_1 abstract view
.subckt sky130_fd_sc_hd__mux2_1 A0 A1 S VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__buf_4 abstract view
.subckt sky130_fd_sc_hd__buf_4 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkbuf_1 abstract view
.subckt sky130_fd_sc_hd__clkbuf_1 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__fill_1 abstract view
.subckt sky130_fd_sc_hd__fill_1 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__fill_2 abstract view
.subckt sky130_fd_sc_hd__fill_2 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__mux4_1 abstract view
.subckt sky130_fd_sc_hd__mux4_1 A0 A1 A2 A3 S0 S1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkbuf_4 abstract view
.subckt sky130_fd_sc_hd__clkbuf_4 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__buf_2 abstract view
.subckt sky130_fd_sc_hd__buf_2 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor3_2 abstract view
.subckt sky130_fd_sc_hd__nor3_2 A B C VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkbuf_8 abstract view
.subckt sky130_fd_sc_hd__clkbuf_8 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkbuf_16 abstract view
.subckt sky130_fd_sc_hd__clkbuf_16 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor3b_2 abstract view
.subckt sky130_fd_sc_hd__nor3b_2 A B C_N VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkbuf_2 abstract view
.subckt sky130_fd_sc_hd__clkbuf_2 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__buf_1 abstract view
.subckt sky130_fd_sc_hd__buf_1 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor2b_2 abstract view
.subckt sky130_fd_sc_hd__nor2b_2 A B_N VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and3b_1 abstract view
.subckt sky130_fd_sc_hd__and3b_1 A_N B C VGND VNB VPB VPWR X
.ends

.subckt dff_ram_4x72 VGND VPWR address[0] address[1] clk en_n rdata[0] rdata[10] rdata[11]
+ rdata[12] rdata[13] rdata[14] rdata[15] rdata[16] rdata[17] rdata[18] rdata[19]
+ rdata[1] rdata[20] rdata[21] rdata[22] rdata[23] rdata[24] rdata[25] rdata[26] rdata[27]
+ rdata[28] rdata[29] rdata[2] rdata[30] rdata[31] rdata[32] rdata[33] rdata[34] rdata[35]
+ rdata[36] rdata[37] rdata[38] rdata[39] rdata[3] rdata[40] rdata[41] rdata[42] rdata[43]
+ rdata[44] rdata[45] rdata[46] rdata[47] rdata[48] rdata[49] rdata[4] rdata[50] rdata[51]
+ rdata[52] rdata[53] rdata[54] rdata[55] rdata[56] rdata[57] rdata[58] rdata[59]
+ rdata[5] rdata[60] rdata[61] rdata[62] rdata[63] rdata[64] rdata[65] rdata[66] rdata[67]
+ rdata[68] rdata[69] rdata[6] rdata[70] rdata[71] rdata[7] rdata[8] rdata[9] wdata[0]
+ wdata[10] wdata[11] wdata[12] wdata[13] wdata[14] wdata[15] wdata[16] wdata[17]
+ wdata[18] wdata[19] wdata[1] wdata[20] wdata[21] wdata[22] wdata[23] wdata[24] wdata[25]
+ wdata[26] wdata[27] wdata[28] wdata[29] wdata[2] wdata[30] wdata[31] wdata[32] wdata[33]
+ wdata[34] wdata[35] wdata[36] wdata[37] wdata[38] wdata[39] wdata[3] wdata[40] wdata[41]
+ wdata[42] wdata[43] wdata[44] wdata[45] wdata[46] wdata[47] wdata[48] wdata[49]
+ wdata[4] wdata[50] wdata[51] wdata[52] wdata[53] wdata[54] wdata[55] wdata[56] wdata[57]
+ wdata[58] wdata[59] wdata[5] wdata[60] wdata[61] wdata[62] wdata[63] wdata[64] wdata[65]
+ wdata[66] wdata[67] wdata[68] wdata[69] wdata[6] wdata[70] wdata[71] wdata[7] wdata[8]
+ wdata[9] wr
X_2037_ clknet_leaf_13_clk _0177_ VGND VGND VPWR VPWR net103 sky130_fd_sc_hd__dfxtp_1
X_2106_ clknet_leaf_10_clk _0246_ VGND VGND VPWR VPWR data\[3\]\[30\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_17_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xhold340 net109 VGND VGND VPWR VPWR net491 sky130_fd_sc_hd__dlygate4sd3_1
Xhold351 net124 VGND VGND VPWR VPWR net502 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_4_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_17_266 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_17_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_23_18 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_63_361 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_51_470 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_23_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_48_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_23_258 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_64_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_8_192 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1270_ net442 _0808_ _0452_ VGND VGND VPWR VPWR _0461_ sky130_fd_sc_hd__mux2_1
X_1606_ net416 _0859_ _0634_ VGND VGND VPWR VPWR _0638_ sky130_fd_sc_hd__mux2_1
X_0985_ _0779_ VGND VGND VPWR VPWR _0816_ sky130_fd_sc_hd__buf_4
XTAP_TAPCELL_ROW_57_507 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1468_ net497 _0881_ _0564_ VGND VGND VPWR VPWR _0565_ sky130_fd_sc_hd__mux2_1
X_1399_ _0528_ VGND VGND VPWR VPWR _0141_ sky130_fd_sc_hd__clkbuf_1
X_1537_ net458 _0424_ _0597_ VGND VGND VPWR VPWR _0601_ sky130_fd_sc_hd__mux2_1
XFILLER_0_49_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_64_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xhold181 data\[1\]\[39\] VGND VGND VPWR VPWR net332 sky130_fd_sc_hd__dlygate4sd3_1
Xhold170 data\[2\]\[22\] VGND VGND VPWR VPWR net321 sky130_fd_sc_hd__dlygate4sd3_1
Xhold192 data\[0\]\[38\] VGND VGND VPWR VPWR net343 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_5_173 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_18_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_55_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_50_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_59_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_51_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1322_ _0488_ VGND VGND VPWR VPWR _0104_ sky130_fd_sc_hd__clkbuf_1
X_1253_ net151 VGND VGND VPWR VPWR _0452_ sky130_fd_sc_hd__buf_4
X_1184_ net1 VGND VGND VPWR VPWR _0399_ sky130_fd_sc_hd__buf_4
XTAP_TAPCELL_ROW_19_264 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_62_543 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_0968_ data\[0\]\[7\] data\[1\]\[7\] data\[2\]\[7\] data\[3\]\[7\] _0798_ _0772_
+ VGND VGND VPWR VPWR _0802_ sky130_fd_sc_hd__mux4_1
XFILLER_0_24_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_2_154 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_33_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_25_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_61_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_45_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_0_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_28_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_24_320 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1871_ clknet_leaf_21_clk _0011_ VGND VGND VPWR VPWR data\[2\]\[11\] sky130_fd_sc_hd__dfxtp_1
X_1940_ clknet_leaf_23_clk _0080_ VGND VGND VPWR VPWR data\[0\]\[8\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_16_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_16_245 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_24_342 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_3_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1305_ _0479_ VGND VGND VPWR VPWR _0096_ sky130_fd_sc_hd__clkbuf_1
X_1236_ data\[0\]\[68\] data\[1\]\[68\] data\[2\]\[68\] data\[3\]\[68\] _0797_ _0805_
+ VGND VGND VPWR VPWR _0439_ sky130_fd_sc_hd__mux4_1
X_1098_ net33 _0902_ _0882_ VGND VGND VPWR VPWR _0903_ sky130_fd_sc_hd__mux2_1
X_1167_ _0386_ VGND VGND VPWR VPWR _0051_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_2_291 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_25_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_25_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_13_226 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_40_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_56_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2070_ clknet_leaf_28_clk _0210_ VGND VGND VPWR VPWR net139 sky130_fd_sc_hd__dfxtp_1
X_1021_ _0843_ VGND VGND VPWR VPWR _0018_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_56_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1785_ net233 _0903_ _0725_ VGND VGND VPWR VPWR _0732_ sky130_fd_sc_hd__mux2_1
XFILLER_0_31_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1854_ net350 _0443_ _0758_ VGND VGND VPWR VPWR _0768_ sky130_fd_sc_hd__mux2_1
X_1923_ clknet_leaf_30_clk _0063_ VGND VGND VPWR VPWR data\[2\]\[63\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_16_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_21_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_12_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2199_ clknet_leaf_2_clk _0339_ VGND VGND VPWR VPWR data\[1\]\[51\] sky130_fd_sc_hd__dfxtp_1
X_1219_ _0426_ VGND VGND VPWR VPWR _0063_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_47_231 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_47_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_10_207 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_15_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xhold63 data\[1\]\[42\] VGND VGND VPWR VPWR net214 sky130_fd_sc_hd__dlygate4sd3_1
Xhold41 data\[1\]\[52\] VGND VGND VPWR VPWR net192 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_30_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_26_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xhold74 data\[3\]\[62\] VGND VGND VPWR VPWR net225 sky130_fd_sc_hd__dlygate4sd3_1
Xhold52 data\[0\]\[11\] VGND VGND VPWR VPWR net203 sky130_fd_sc_hd__dlygate4sd3_1
Xhold30 data\[1\]\[2\] VGND VGND VPWR VPWR net181 sky130_fd_sc_hd__dlygate4sd3_1
Xhold85 data\[0\]\[28\] VGND VGND VPWR VPWR net236 sky130_fd_sc_hd__dlygate4sd3_1
Xhold96 data\[2\]\[65\] VGND VGND VPWR VPWR net247 sky130_fd_sc_hd__dlygate4sd3_1
X_1570_ net295 _0800_ _0612_ VGND VGND VPWR VPWR _0619_ sky130_fd_sc_hd__mux2_1
XFILLER_0_21_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2122_ clknet_leaf_5_clk _0262_ VGND VGND VPWR VPWR data\[3\]\[46\] sky130_fd_sc_hd__dfxtp_1
X_2053_ clknet_leaf_9_clk _0193_ VGND VGND VPWR VPWR net120 sky130_fd_sc_hd__dfxtp_1
XFILLER_0_20_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1004_ data\[0\]\[15\] data\[1\]\[15\] data\[2\]\[15\] data\[3\]\[15\] _0798_ _0806_
+ VGND VGND VPWR VPWR _0830_ sky130_fd_sc_hd__mux4_1
X_1906_ clknet_leaf_5_clk _0046_ VGND VGND VPWR VPWR data\[2\]\[46\] sky130_fd_sc_hd__dfxtp_1
X_1768_ net229 _0876_ _0714_ VGND VGND VPWR VPWR _0723_ sky130_fd_sc_hd__mux2_1
X_1837_ _0759_ VGND VGND VPWR VPWR _0348_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_12_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1699_ _0686_ VGND VGND VPWR VPWR _0283_ sky130_fd_sc_hd__clkbuf_1
Xoutput97 net97 VGND VGND VPWR VPWR rdata[28] sky130_fd_sc_hd__clkbuf_4
Xoutput86 net86 VGND VGND VPWR VPWR rdata[18] sky130_fd_sc_hd__buf_2
XTAP_TAPCELL_ROW_54_490 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_46_435 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1622_ _0646_ VGND VGND VPWR VPWR _0246_ sky130_fd_sc_hd__clkbuf_1
X_1484_ net506 _0909_ _0564_ VGND VGND VPWR VPWR _0573_ sky130_fd_sc_hd__mux2_1
X_1553_ net489 _0448_ _0778_ VGND VGND VPWR VPWR _0609_ sky130_fd_sc_hd__mux2_1
X_2105_ clknet_leaf_13_clk _0245_ VGND VGND VPWR VPWR data\[3\]\[29\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_49_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2036_ clknet_leaf_11_clk _0176_ VGND VGND VPWR VPWR net102 sky130_fd_sc_hd__dfxtp_1
XFILLER_0_27_72 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_64_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_32_226 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xhold352 net87 VGND VGND VPWR VPWR net503 sky130_fd_sc_hd__dlygate4sd3_1
Xhold330 net140 VGND VGND VPWR VPWR net481 sky130_fd_sc_hd__dlygate4sd3_1
Xhold341 net85 VGND VGND VPWR VPWR net492 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_43_416 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_63_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_51_471 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_31_292 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_8_193 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_64_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_46_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_0984_ net5 _0813_ _0814_ VGND VGND VPWR VPWR _0815_ sky130_fd_sc_hd__mux2_1
X_1605_ _0637_ VGND VGND VPWR VPWR _0238_ sky130_fd_sc_hd__clkbuf_1
X_1536_ _0600_ VGND VGND VPWR VPWR _0206_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_14_226 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_57_508 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1467_ _0778_ VGND VGND VPWR VPWR _0564_ sky130_fd_sc_hd__buf_4
XFILLER_0_38_71 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1398_ net373 _0443_ _0518_ VGND VGND VPWR VPWR _0528_ sky130_fd_sc_hd__mux2_1
XFILLER_0_64_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2019_ clknet_leaf_20_clk _0159_ VGND VGND VPWR VPWR net83 sky130_fd_sc_hd__dfxtp_1
XPHY_EDGE_ROW_19_Left_84 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_60_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_60_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold160 data\[2\]\[37\] VGND VGND VPWR VPWR net311 sky130_fd_sc_hd__dlygate4sd3_1
Xhold193 data\[1\]\[46\] VGND VGND VPWR VPWR net344 sky130_fd_sc_hd__dlygate4sd3_1
Xhold171 data\[1\]\[49\] VGND VGND VPWR VPWR net322 sky130_fd_sc_hd__dlygate4sd3_1
Xhold182 data\[2\]\[54\] VGND VGND VPWR VPWR net333 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_34_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_5_174 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_55_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_59_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_11_207 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1321_ net193 _0890_ _0485_ VGND VGND VPWR VPWR _0488_ sky130_fd_sc_hd__mux2_1
X_1252_ _0771_ _0805_ _0777_ VGND VGND VPWR VPWR _0451_ sky130_fd_sc_hd__nor3_2
XTAP_TAPCELL_ROW_62_544 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1183_ _0398_ VGND VGND VPWR VPWR _0055_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_19_265 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_42_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_42_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_27_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_0967_ _0801_ VGND VGND VPWR VPWR _0006_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_6_234 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_6_256 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_64_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1519_ _0591_ VGND VGND VPWR VPWR _0198_ sky130_fd_sc_hd__clkbuf_1
XPHY_EDGE_ROW_12_Right_12 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_2_155 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_21_Right_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_4_Left_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_30_Right_30 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_61_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_16_246 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_3_204 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1870_ clknet_leaf_24_clk _0010_ VGND VGND VPWR VPWR data\[2\]\[10\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_51_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_51_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_50_9 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1304_ net450 _0862_ _0474_ VGND VGND VPWR VPWR _0479_ sky130_fd_sc_hd__mux2_1
X_1166_ net309 _0385_ _0382_ VGND VGND VPWR VPWR _0386_ sky130_fd_sc_hd__mux2_1
X_1235_ _0438_ VGND VGND VPWR VPWR _0067_ sky130_fd_sc_hd__clkbuf_1
X_1097_ data\[0\]\[36\] data\[1\]\[36\] data\[2\]\[36\] data\[3\]\[36\] _0901_ _0874_
+ VGND VGND VPWR VPWR _0902_ sky130_fd_sc_hd__mux4_1
XFILLER_0_42_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_15_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1999_ clknet_leaf_1_clk _0139_ VGND VGND VPWR VPWR data\[0\]\[67\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_21_379 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_56_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_56_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1020_ net209 _0842_ _0816_ VGND VGND VPWR VPWR _0843_ sky130_fd_sc_hd__mux2_1
XFILLER_0_56_210 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1922_ clknet_leaf_27_clk _0062_ VGND VGND VPWR VPWR data\[2\]\[62\] sky130_fd_sc_hd__dfxtp_1
X_1784_ _0731_ VGND VGND VPWR VPWR _0323_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_16_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1853_ _0767_ VGND VGND VPWR VPWR _0356_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_12_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2198_ clknet_leaf_0_clk _0338_ VGND VGND VPWR VPWR data\[1\]\[50\] sky130_fd_sc_hd__dfxtp_1
X_1149_ net2 VGND VGND VPWR VPWR _0372_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_1_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1218_ net287 _0425_ _0416_ VGND VGND VPWR VPWR _0426_ sky130_fd_sc_hd__mux2_1
XFILLER_0_47_298 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold53 data\[2\]\[29\] VGND VGND VPWR VPWR net204 sky130_fd_sc_hd__dlygate4sd3_1
Xhold64 data\[1\]\[33\] VGND VGND VPWR VPWR net215 sky130_fd_sc_hd__dlygate4sd3_1
Xhold42 data\[0\]\[32\] VGND VGND VPWR VPWR net193 sky130_fd_sc_hd__dlygate4sd3_1
Xhold31 data\[0\]\[52\] VGND VGND VPWR VPWR net182 sky130_fd_sc_hd__dlygate4sd3_1
Xhold97 data\[3\]\[15\] VGND VGND VPWR VPWR net248 sky130_fd_sc_hd__dlygate4sd3_1
Xhold86 data\[0\]\[67\] VGND VGND VPWR VPWR net237 sky130_fd_sc_hd__dlygate4sd3_1
Xhold75 data\[2\]\[17\] VGND VGND VPWR VPWR net226 sky130_fd_sc_hd__dlygate4sd3_1
Xhold20 data\[1\]\[17\] VGND VGND VPWR VPWR net171 sky130_fd_sc_hd__dlygate4sd3_1
XPHY_EDGE_ROW_7_Left_72 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_6_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2121_ clknet_leaf_7_clk _0261_ VGND VGND VPWR VPWR data\[3\]\[45\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_49_455 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2052_ clknet_leaf_5_clk _0192_ VGND VGND VPWR VPWR net119 sky130_fd_sc_hd__dfxtp_1
X_1003_ _0829_ VGND VGND VPWR VPWR _0014_ sky130_fd_sc_hd__clkbuf_1
X_1905_ clknet_leaf_7_clk _0045_ VGND VGND VPWR VPWR data\[2\]\[45\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_32_62 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_32_344 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_29_254 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1767_ _0722_ VGND VGND VPWR VPWR _0315_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_4_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_6_Right_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1836_ net219 _0415_ _0758_ VGND VGND VPWR VPWR _0759_ sky130_fd_sc_hd__mux2_1
XFILLER_0_12_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1698_ net338 _0437_ _0678_ VGND VGND VPWR VPWR _0686_ sky130_fd_sc_hd__mux2_1
XFILLER_0_35_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xoutput98 net98 VGND VGND VPWR VPWR rdata[29] sky130_fd_sc_hd__clkbuf_4
XFILLER_0_43_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_33_Left_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xoutput87 net87 VGND VGND VPWR VPWR rdata[19] sky130_fd_sc_hd__buf_2
XTAP_TAPCELL_ROW_46_436 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_59_Right_59 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_54_491 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1621_ net274 _0883_ _0645_ VGND VGND VPWR VPWR _0646_ sky130_fd_sc_hd__mux2_1
X_1552_ _0608_ VGND VGND VPWR VPWR _0214_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_1_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1483_ _0572_ VGND VGND VPWR VPWR _0181_ sky130_fd_sc_hd__clkbuf_1
X_2104_ clknet_leaf_11_clk _0244_ VGND VGND VPWR VPWR data\[3\]\[28\] sky130_fd_sc_hd__dfxtp_1
X_2035_ clknet_leaf_12_clk _0175_ VGND VGND VPWR VPWR net101 sky130_fd_sc_hd__dfxtp_1
XFILLER_0_49_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_43_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_11_6 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_202 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xhold342 net97 VGND VGND VPWR VPWR net493 sky130_fd_sc_hd__dlygate4sd3_1
X_1819_ net192 _0388_ _0747_ VGND VGND VPWR VPWR _0750_ sky130_fd_sc_hd__mux2_1
Xhold320 net128 VGND VGND VPWR VPWR net471 sky130_fd_sc_hd__dlygate4sd3_1
Xhold353 net110 VGND VGND VPWR VPWR net504 sky130_fd_sc_hd__dlygate4sd3_1
Xhold331 net81 VGND VGND VPWR VPWR net482 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_51_472 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_43_417 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_64_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_8_194 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_54_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_0983_ _0774_ VGND VGND VPWR VPWR _0814_ sky130_fd_sc_hd__buf_4
XFILLER_0_13_31 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1604_ net413 _0856_ _0634_ VGND VGND VPWR VPWR _0637_ sky130_fd_sc_hd__mux2_1
X_1535_ net455 _0421_ _0597_ VGND VGND VPWR VPWR _0600_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_57_509 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1466_ _0563_ VGND VGND VPWR VPWR _0173_ sky130_fd_sc_hd__clkbuf_1
X_1397_ _0527_ VGND VGND VPWR VPWR _0140_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_49_124 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_49_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2018_ clknet_leaf_20_clk _0158_ VGND VGND VPWR VPWR net82 sky130_fd_sc_hd__dfxtp_1
XFILLER_0_60_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_60_333 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold150 data\[1\]\[37\] VGND VGND VPWR VPWR net301 sky130_fd_sc_hd__dlygate4sd3_1
Xhold172 data\[0\]\[47\] VGND VGND VPWR VPWR net323 sky130_fd_sc_hd__dlygate4sd3_1
Xhold161 data\[3\]\[38\] VGND VGND VPWR VPWR net312 sky130_fd_sc_hd__dlygate4sd3_1
Xhold194 data\[2\]\[38\] VGND VGND VPWR VPWR net345 sky130_fd_sc_hd__dlygate4sd3_1
Xhold183 data\[3\]\[65\] VGND VGND VPWR VPWR net334 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_50_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1320_ _0487_ VGND VGND VPWR VPWR _0103_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_11_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1182_ net445 _0397_ _0382_ VGND VGND VPWR VPWR _0398_ sky130_fd_sc_hd__mux2_1
X_1251_ _0450_ VGND VGND VPWR VPWR _0071_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_62_545 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_20_Left_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_24_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_24_63 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_0966_ net426 _0800_ _0780_ VGND VGND VPWR VPWR _0801_ sky130_fd_sc_hd__mux2_1
XFILLER_0_57_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1449_ net242 _0852_ _0553_ VGND VGND VPWR VPWR _0555_ sky130_fd_sc_hd__mux2_1
X_1518_ net505 _0393_ _0586_ VGND VGND VPWR VPWR _0591_ sky130_fd_sc_hd__mux2_1
XFILLER_0_4_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_52_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_45_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_60_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1303_ _0478_ VGND VGND VPWR VPWR _0095_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_19_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1096_ _0797_ VGND VGND VPWR VPWR _0901_ sky130_fd_sc_hd__buf_4
X_1165_ net50 _0384_ _0380_ VGND VGND VPWR VPWR _0385_ sky130_fd_sc_hd__mux2_1
X_1234_ net381 _0437_ _0416_ VGND VGND VPWR VPWR _0438_ sky130_fd_sc_hd__mux2_1
XFILLER_0_19_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_42_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_30_347 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1998_ clknet_leaf_28_clk _0138_ VGND VGND VPWR VPWR data\[0\]\[66\] sky130_fd_sc_hd__dfxtp_1
X_0949_ _0787_ VGND VGND VPWR VPWR _0002_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_15_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_38_383 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_33_152 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_18_171 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_0_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_56_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1921_ clknet_leaf_29_clk _0061_ VGND VGND VPWR VPWR data\[2\]\[61\] sky130_fd_sc_hd__dfxtp_1
X_1852_ net252 _0440_ _0758_ VGND VGND VPWR VPWR _0767_ sky130_fd_sc_hd__mux2_1
XFILLER_0_21_31 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1783_ net279 _0899_ _0725_ VGND VGND VPWR VPWR _0731_ sky130_fd_sc_hd__mux2_1
X_1079_ _0888_ VGND VGND VPWR VPWR _0031_ sky130_fd_sc_hd__clkbuf_1
X_1148_ _0371_ VGND VGND VPWR VPWR _0047_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_46_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2197_ clknet_leaf_2_clk _0337_ VGND VGND VPWR VPWR data\[1\]\[49\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_35_364 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1217_ net63 _0424_ _0414_ VGND VGND VPWR VPWR _0425_ sky130_fd_sc_hd__mux2_1
XPHY_EDGE_ROW_42_Left_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold32 data\[3\]\[37\] VGND VGND VPWR VPWR net183 sky130_fd_sc_hd__dlygate4sd3_1
Xhold10 data\[3\]\[42\] VGND VGND VPWR VPWR net161 sky130_fd_sc_hd__dlygate4sd3_1
Xhold43 data\[0\]\[37\] VGND VGND VPWR VPWR net194 sky130_fd_sc_hd__dlygate4sd3_1
Xhold87 data\[2\]\[44\] VGND VGND VPWR VPWR net238 sky130_fd_sc_hd__dlygate4sd3_1
Xhold21 data\[2\]\[26\] VGND VGND VPWR VPWR net172 sky130_fd_sc_hd__dlygate4sd3_1
Xhold65 data\[0\]\[16\] VGND VGND VPWR VPWR net216 sky130_fd_sc_hd__dlygate4sd3_1
Xhold76 data\[3\]\[3\] VGND VGND VPWR VPWR net227 sky130_fd_sc_hd__dlygate4sd3_1
Xhold98 data\[3\]\[7\] VGND VGND VPWR VPWR net249 sky130_fd_sc_hd__dlygate4sd3_1
Xhold54 data\[1\]\[13\] VGND VGND VPWR VPWR net205 sky130_fd_sc_hd__dlygate4sd3_1
XPHY_EDGE_ROW_51_Left_116 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_53_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2120_ clknet_leaf_6_clk _0260_ VGND VGND VPWR VPWR data\[3\]\[44\] sky130_fd_sc_hd__dfxtp_1
XPHY_EDGE_ROW_60_Left_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_21_199 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_49_456 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2051_ clknet_leaf_5_clk _0191_ VGND VGND VPWR VPWR net118 sky130_fd_sc_hd__dfxtp_1
X_1002_ net186 _0828_ _0816_ VGND VGND VPWR VPWR _0829_ sky130_fd_sc_hd__mux2_1
XFILLER_0_16_64 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1904_ clknet_leaf_6_clk _0044_ VGND VGND VPWR VPWR data\[2\]\[44\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_44_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_32_345 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_32_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_29_266 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_29_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_4_333 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1835_ _0691_ VGND VGND VPWR VPWR _0758_ sky130_fd_sc_hd__buf_4
X_1766_ net407 _0872_ _0714_ VGND VGND VPWR VPWR _0722_ sky130_fd_sc_hd__mux2_1
XFILLER_0_4_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_12_122 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1697_ _0685_ VGND VGND VPWR VPWR _0282_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_35_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_35_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_7_182 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xoutput77 net77 VGND VGND VPWR VPWR rdata[0] sky130_fd_sc_hd__clkbuf_4
Xoutput88 net88 VGND VGND VPWR VPWR rdata[1] sky130_fd_sc_hd__clkbuf_4
Xoutput99 net99 VGND VGND VPWR VPWR rdata[2] sky130_fd_sc_hd__clkbuf_4
XFILLER_0_9_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_46_437 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_54_492 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_26_258 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_26_236 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1482_ net454 _0905_ _0564_ VGND VGND VPWR VPWR _0572_ sky130_fd_sc_hd__mux2_1
X_1620_ _0611_ VGND VGND VPWR VPWR _0645_ sky130_fd_sc_hd__buf_4
X_1551_ net507 _0445_ _0778_ VGND VGND VPWR VPWR _0608_ sky130_fd_sc_hd__mux2_1
X_2103_ clknet_leaf_14_clk _0243_ VGND VGND VPWR VPWR data\[3\]\[27\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_64_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2034_ clknet_leaf_11_clk _0174_ VGND VGND VPWR VPWR net100 sky130_fd_sc_hd__dfxtp_1
X_1818_ _0749_ VGND VGND VPWR VPWR _0339_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_4_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xhold310 net139 VGND VGND VPWR VPWR net461 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_40_294 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_40_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xhold321 net127 VGND VGND VPWR VPWR net472 sky130_fd_sc_hd__dlygate4sd3_1
Xhold354 net126 VGND VGND VPWR VPWR net505 sky130_fd_sc_hd__dlygate4sd3_1
X_1749_ net385 _0845_ _0703_ VGND VGND VPWR VPWR _0713_ sky130_fd_sc_hd__mux2_1
Xhold343 net122 VGND VGND VPWR VPWR net494 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_7_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xhold332 net99 VGND VGND VPWR VPWR net483 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_51_473 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_43_418 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_0982_ data\[0\]\[10\] data\[1\]\[10\] data\[2\]\[10\] data\[3\]\[10\] _0798_ _0806_
+ VGND VGND VPWR VPWR _0813_ sky130_fd_sc_hd__mux4_1
X_1465_ net464 _0878_ _0553_ VGND VGND VPWR VPWR _0563_ sky130_fd_sc_hd__mux2_1
X_1603_ _0636_ VGND VGND VPWR VPWR _0237_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_1_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1534_ _0599_ VGND VGND VPWR VPWR _0205_ sky130_fd_sc_hd__clkbuf_1
X_2017_ clknet_leaf_19_clk _0157_ VGND VGND VPWR VPWR net81 sky130_fd_sc_hd__dfxtp_1
X_1396_ net378 _0440_ _0518_ VGND VGND VPWR VPWR _0527_ sky130_fd_sc_hd__mux2_1
XFILLER_0_64_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_64_128 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_37_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_60_345 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_60_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xhold151 data\[2\]\[32\] VGND VGND VPWR VPWR net302 sky130_fd_sc_hd__dlygate4sd3_1
Xhold162 data\[2\]\[48\] VGND VGND VPWR VPWR net313 sky130_fd_sc_hd__dlygate4sd3_1
Xhold140 data\[1\]\[71\] VGND VGND VPWR VPWR net291 sky130_fd_sc_hd__dlygate4sd3_1
Xhold195 data\[3\]\[34\] VGND VGND VPWR VPWR net346 sky130_fd_sc_hd__dlygate4sd3_1
Xhold184 data\[2\]\[50\] VGND VGND VPWR VPWR net335 sky130_fd_sc_hd__dlygate4sd3_1
Xhold173 data\[3\]\[13\] VGND VGND VPWR VPWR net324 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_55_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_63_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_51_323 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1181_ net54 _0396_ _0380_ VGND VGND VPWR VPWR _0397_ sky130_fd_sc_hd__mux2_1
X_1250_ net234 _0449_ _0779_ VGND VGND VPWR VPWR _0450_ sky130_fd_sc_hd__mux2_1
XFILLER_0_19_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_40_63 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0965_ net70 _0799_ _0775_ VGND VGND VPWR VPWR _0800_ sky130_fd_sc_hd__mux2_1
X_1448_ _0554_ VGND VGND VPWR VPWR _0164_ sky130_fd_sc_hd__clkbuf_1
X_1517_ _0590_ VGND VGND VPWR VPWR _0197_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_4_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_10_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1379_ _0451_ VGND VGND VPWR VPWR _0518_ sky130_fd_sc_hd__buf_4
XFILLER_0_60_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_10_88 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_24_292 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1302_ net410 _0859_ _0474_ VGND VGND VPWR VPWR _0478_ sky130_fd_sc_hd__mux2_1
X_1233_ net67 _0436_ _0414_ VGND VGND VPWR VPWR _0437_ sky130_fd_sc_hd__mux2_1
XFILLER_0_59_264 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1095_ _0900_ VGND VGND VPWR VPWR _0035_ sky130_fd_sc_hd__clkbuf_1
X_1164_ data\[0\]\[51\] data\[1\]\[51\] data\[2\]\[51\] data\[3\]\[51\] _0365_ _0372_
+ VGND VGND VPWR VPWR _0384_ sky130_fd_sc_hd__mux4_1
XFILLER_0_51_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_0948_ net245 _0786_ _0780_ VGND VGND VPWR VPWR _0787_ sky130_fd_sc_hd__mux2_1
X_1997_ clknet_leaf_30_clk _0137_ VGND VGND VPWR VPWR data\[0\]\[65\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_30_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_15_356 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_38_384 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_33_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_21_273 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_21_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_8_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1920_ clknet_leaf_29_clk _0060_ VGND VGND VPWR VPWR data\[2\]\[60\] sky130_fd_sc_hd__dfxtp_1
X_1851_ _0766_ VGND VGND VPWR VPWR _0355_ sky130_fd_sc_hd__clkbuf_1
X_1782_ _0730_ VGND VGND VPWR VPWR _0322_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_12_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_46_40 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2196_ clknet_leaf_5_clk _0336_ VGND VGND VPWR VPWR data\[1\]\[48\] sky130_fd_sc_hd__dfxtp_1
X_1216_ data\[0\]\[63\] data\[1\]\[63\] data\[2\]\[63\] data\[3\]\[63\] _0399_ _0406_
+ VGND VGND VPWR VPWR _0424_ sky130_fd_sc_hd__mux4_1
XFILLER_0_20_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_62_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1078_ net290 _0887_ _0884_ VGND VGND VPWR VPWR _0888_ sky130_fd_sc_hd__mux2_1
X_1147_ net272 _0370_ _0918_ VGND VGND VPWR VPWR _0371_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_35_365 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_47_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xhold11 data\[1\]\[1\] VGND VGND VPWR VPWR net162 sky130_fd_sc_hd__dlygate4sd3_1
Xhold22 data\[3\]\[68\] VGND VGND VPWR VPWR net173 sky130_fd_sc_hd__dlygate4sd3_1
Xhold99 data\[1\]\[43\] VGND VGND VPWR VPWR net250 sky130_fd_sc_hd__dlygate4sd3_1
Xhold55 data\[0\]\[40\] VGND VGND VPWR VPWR net206 sky130_fd_sc_hd__dlygate4sd3_1
Xhold33 data\[2\]\[28\] VGND VGND VPWR VPWR net184 sky130_fd_sc_hd__dlygate4sd3_1
Xhold88 data\[3\]\[19\] VGND VGND VPWR VPWR net239 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_26_310 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xhold66 data\[2\]\[16\] VGND VGND VPWR VPWR net217 sky130_fd_sc_hd__dlygate4sd3_1
Xhold77 data\[1\]\[61\] VGND VGND VPWR VPWR net228 sky130_fd_sc_hd__dlygate4sd3_1
Xhold44 data\[0\]\[2\] VGND VGND VPWR VPWR net195 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_38_256 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_38_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_61_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_21_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2050_ clknet_leaf_6_clk _0190_ VGND VGND VPWR VPWR net117 sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_49_457 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1001_ net9 _0827_ _0814_ VGND VGND VPWR VPWR _0828_ sky130_fd_sc_hd__mux2_1
XFILLER_0_16_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_16_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_16_76 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1765_ _0721_ VGND VGND VPWR VPWR _0314_ sky130_fd_sc_hd__clkbuf_1
X_1903_ clknet_leaf_6_clk _0043_ VGND VGND VPWR VPWR data\[2\]\[43\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_32_346 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1834_ _0757_ VGND VGND VPWR VPWR _0347_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_4_345 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_12_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1696_ net310 _0434_ _0678_ VGND VGND VPWR VPWR _0685_ sky130_fd_sc_hd__mux2_1
X_2179_ clknet_leaf_12_clk _0319_ VGND VGND VPWR VPWR data\[1\]\[31\] sky130_fd_sc_hd__dfxtp_1
Xoutput89 net89 VGND VGND VPWR VPWR rdata[20] sky130_fd_sc_hd__clkbuf_4
Xoutput78 net78 VGND VGND VPWR VPWR rdata[10] sky130_fd_sc_hd__buf_2
XFILLER_0_58_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_46_438 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_54_493 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_26_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1481_ _0571_ VGND VGND VPWR VPWR _0180_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_1_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1550_ _0607_ VGND VGND VPWR VPWR _0213_ sky130_fd_sc_hd__clkbuf_1
X_2102_ clknet_leaf_14_clk _0242_ VGND VGND VPWR VPWR data\[3\]\[26\] sky130_fd_sc_hd__dfxtp_1
X_2033_ clknet_leaf_13_clk _0173_ VGND VGND VPWR VPWR net98 sky130_fd_sc_hd__dfxtp_1
Xhold333 net102 VGND VGND VPWR VPWR net484 sky130_fd_sc_hd__dlygate4sd3_1
Xhold300 data\[0\]\[39\] VGND VGND VPWR VPWR net451 sky130_fd_sc_hd__dlygate4sd3_1
Xhold322 net89 VGND VGND VPWR VPWR net473 sky130_fd_sc_hd__dlygate4sd3_1
Xhold344 net104 VGND VGND VPWR VPWR net495 sky130_fd_sc_hd__dlygate4sd3_1
X_1817_ net427 _0385_ _0747_ VGND VGND VPWR VPWR _0749_ sky130_fd_sc_hd__mux2_1
Xhold311 net86 VGND VGND VPWR VPWR net462 sky130_fd_sc_hd__dlygate4sd3_1
X_1748_ _0712_ VGND VGND VPWR VPWR _0306_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_7_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_17_259 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold355 net108 VGND VGND VPWR VPWR net506 sky130_fd_sc_hd__dlygate4sd3_1
X_1679_ net387 _0408_ _0667_ VGND VGND VPWR VPWR _0676_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_43_419 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_64_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_13_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_13_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_0981_ _0812_ VGND VGND VPWR VPWR _0009_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_54_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1602_ net177 _0853_ _0634_ VGND VGND VPWR VPWR _0636_ sky130_fd_sc_hd__mux2_1
X_1464_ _0562_ VGND VGND VPWR VPWR _0172_ sky130_fd_sc_hd__clkbuf_1
X_1533_ net468 _0418_ _0597_ VGND VGND VPWR VPWR _0599_ sky130_fd_sc_hd__mux2_1
X_1395_ _0526_ VGND VGND VPWR VPWR _0139_ sky130_fd_sc_hd__clkbuf_1
X_2016_ clknet_leaf_22_clk _0156_ VGND VGND VPWR VPWR net80 sky130_fd_sc_hd__dfxtp_1
XFILLER_0_45_310 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_9_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_leaf_30_clk clknet_2_0__leaf_clk VGND VGND VPWR VPWR clknet_leaf_30_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_0_60_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xhold174 data\[2\]\[43\] VGND VGND VPWR VPWR net325 sky130_fd_sc_hd__dlygate4sd3_1
Xhold141 data\[3\]\[36\] VGND VGND VPWR VPWR net292 sky130_fd_sc_hd__dlygate4sd3_1
Xhold152 data\[1\]\[34\] VGND VGND VPWR VPWR net303 sky130_fd_sc_hd__dlygate4sd3_1
Xhold185 net143 VGND VGND VPWR VPWR net336 sky130_fd_sc_hd__dlygate4sd3_1
Xhold163 data\[1\]\[6\] VGND VGND VPWR VPWR net314 sky130_fd_sc_hd__dlygate4sd3_1
Xhold130 data\[1\]\[66\] VGND VGND VPWR VPWR net281 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_56_500 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xhold196 data\[0\]\[3\] VGND VGND VPWR VPWR net347 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_48_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_36_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xclkbuf_leaf_21_clk clknet_2_2__leaf_clk VGND VGND VPWR VPWR clknet_leaf_21_clk sky130_fd_sc_hd__clkbuf_8
X_1180_ data\[0\]\[55\] data\[1\]\[55\] data\[2\]\[55\] data\[3\]\[55\] _0365_ _0372_
+ VGND VGND VPWR VPWR _0396_ sky130_fd_sc_hd__mux4_1
Xclkbuf_leaf_12_clk clknet_2_3__leaf_clk VGND VGND VPWR VPWR clknet_leaf_12_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_0_27_310 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_0964_ data\[0\]\[6\] data\[1\]\[6\] data\[2\]\[6\] data\[3\]\[6\] _0798_ _0772_
+ VGND VGND VPWR VPWR _0799_ sky130_fd_sc_hd__mux4_1
XFILLER_0_40_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1516_ net125 _0390_ _0586_ VGND VGND VPWR VPWR _0590_ sky130_fd_sc_hd__mux2_1
XFILLER_0_10_232 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1447_ net473 _0847_ _0553_ VGND VGND VPWR VPWR _0554_ sky130_fd_sc_hd__mux2_1
X_1378_ _0517_ VGND VGND VPWR VPWR _0131_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_33_379 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_5_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_18_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_18_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_28_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_24_293 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_51_198 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_24_324 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1301_ _0477_ VGND VGND VPWR VPWR _0094_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_19_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_19_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1232_ data\[0\]\[67\] data\[1\]\[67\] data\[2\]\[67\] data\[3\]\[67\] _0797_ _0406_
+ VGND VGND VPWR VPWR _0436_ sky130_fd_sc_hd__mux4_1
Xclkbuf_leaf_1_clk clknet_2_0__leaf_clk VGND VGND VPWR VPWR clknet_leaf_1_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_0_59_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1094_ net330 _0899_ _0884_ VGND VGND VPWR VPWR _0900_ sky130_fd_sc_hd__mux2_1
XFILLER_0_35_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_35_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1163_ _0383_ VGND VGND VPWR VPWR _0050_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_27_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_27_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1996_ clknet_leaf_29_clk _0136_ VGND VGND VPWR VPWR data\[0\]\[64\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_15_324 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_0947_ net26 _0785_ _0775_ VGND VGND VPWR VPWR _0786_ sky130_fd_sc_hd__mux2_1
XFILLER_0_62_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_38_385 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_21_274 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_56_202 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_29_330 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1781_ net303 _0896_ _0725_ VGND VGND VPWR VPWR _0730_ sky130_fd_sc_hd__mux2_1
X_1850_ net170 _0437_ _0758_ VGND VGND VPWR VPWR _0766_ sky130_fd_sc_hd__mux2_1
X_2195_ clknet_leaf_5_clk _0335_ VGND VGND VPWR VPWR data\[1\]\[47\] sky130_fd_sc_hd__dfxtp_1
X_1146_ net45 _0369_ _0916_ VGND VGND VPWR VPWR _0370_ sky130_fd_sc_hd__mux2_1
X_1215_ _0423_ VGND VGND VPWR VPWR _0062_ sky130_fd_sc_hd__clkbuf_1
X_1077_ net28 _0886_ _0882_ VGND VGND VPWR VPWR _0887_ sky130_fd_sc_hd__mux2_1
XFILLER_0_47_268 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_47_235 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_35_366 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_7_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_62_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1979_ clknet_leaf_5_clk _0119_ VGND VGND VPWR VPWR data\[0\]\[47\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_30_102 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_15_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_15_198 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold45 data\[0\]\[48\] VGND VGND VPWR VPWR net196 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_30_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xhold34 data\[2\]\[11\] VGND VGND VPWR VPWR net185 sky130_fd_sc_hd__dlygate4sd3_1
Xhold12 data\[3\]\[60\] VGND VGND VPWR VPWR net163 sky130_fd_sc_hd__dlygate4sd3_1
Xhold23 data\[1\]\[63\] VGND VGND VPWR VPWR net174 sky130_fd_sc_hd__dlygate4sd3_1
Xhold56 data\[3\]\[63\] VGND VGND VPWR VPWR net207 sky130_fd_sc_hd__dlygate4sd3_1
Xhold78 data\[1\]\[28\] VGND VGND VPWR VPWR net229 sky130_fd_sc_hd__dlygate4sd3_1
Xhold67 data\[2\]\[30\] VGND VGND VPWR VPWR net218 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_26_311 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xhold89 data\[1\]\[64\] VGND VGND VPWR VPWR net240 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_61_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_49_458 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1000_ data\[0\]\[14\] data\[1\]\[14\] data\[2\]\[14\] data\[3\]\[14\] _0798_ _0806_
+ VGND VGND VPWR VPWR _0827_ sky130_fd_sc_hd__mux4_1
X_1902_ clknet_leaf_7_clk _0042_ VGND VGND VPWR VPWR data\[2\]\[42\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_32_347 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_29_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1764_ net270 _0869_ _0714_ VGND VGND VPWR VPWR _0721_ sky130_fd_sc_hd__mux2_1
XFILLER_0_44_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_44_227 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1833_ net340 _0411_ _0747_ VGND VGND VPWR VPWR _0757_ sky130_fd_sc_hd__mux2_1
XFILLER_0_4_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_57_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1695_ _0684_ VGND VGND VPWR VPWR _0281_ sky130_fd_sc_hd__clkbuf_1
X_1129_ net41 _0926_ _0916_ VGND VGND VPWR VPWR _0927_ sky130_fd_sc_hd__mux2_1
X_2178_ clknet_leaf_10_clk _0318_ VGND VGND VPWR VPWR data\[1\]\[30\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_25_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_35_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xoutput79 net79 VGND VGND VPWR VPWR rdata[11] sky130_fd_sc_hd__clkbuf_4
XTAP_TAPCELL_ROW_46_439 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_19_Right_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_26_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_1_305 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1480_ net477 _0902_ _0564_ VGND VGND VPWR VPWR _0571_ sky130_fd_sc_hd__mux2_1
XPHY_EDGE_ROW_28_Right_28 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_1_349 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2032_ clknet_leaf_14_clk _0172_ VGND VGND VPWR VPWR net97 sky130_fd_sc_hd__dfxtp_1
XPHY_EDGE_ROW_37_Right_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2101_ clknet_leaf_16_clk _0241_ VGND VGND VPWR VPWR data\[3\]\[25\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_27_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_27_32 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold312 net103 VGND VGND VPWR VPWR net463 sky130_fd_sc_hd__dlygate4sd3_1
Xhold323 net111 VGND VGND VPWR VPWR net474 sky130_fd_sc_hd__dlygate4sd3_1
XPHY_EDGE_ROW_46_Right_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold356 net144 VGND VGND VPWR VPWR net507 sky130_fd_sc_hd__dlygate4sd3_1
X_1816_ _0748_ VGND VGND VPWR VPWR _0338_ sky130_fd_sc_hd__clkbuf_1
X_1747_ net251 _0842_ _0703_ VGND VGND VPWR VPWR _0712_ sky130_fd_sc_hd__mux2_1
X_1678_ _0675_ VGND VGND VPWR VPWR _0273_ sky130_fd_sc_hd__clkbuf_1
Xhold301 net79 VGND VGND VPWR VPWR net452 sky130_fd_sc_hd__dlygate4sd3_1
Xhold334 net142 VGND VGND VPWR VPWR net485 sky130_fd_sc_hd__dlygate4sd3_1
Xhold345 net141 VGND VGND VPWR VPWR net496 sky130_fd_sc_hd__dlygate4sd3_1
XPHY_EDGE_ROW_55_Right_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_64_Right_64 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_39_Left_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_59_520 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_48_Left_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_54_344 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_54_322 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_0980_ net190 _0811_ _0780_ VGND VGND VPWR VPWR _0812_ sky130_fd_sc_hd__mux2_1
XPHY_EDGE_ROW_57_Left_122 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1601_ _0635_ VGND VGND VPWR VPWR _0236_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_1_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1532_ _0598_ VGND VGND VPWR VPWR _0204_ sky130_fd_sc_hd__clkbuf_1
X_1463_ net493 _0875_ _0553_ VGND VGND VPWR VPWR _0562_ sky130_fd_sc_hd__mux2_1
X_1394_ net237 _0437_ _0518_ VGND VGND VPWR VPWR _0526_ sky130_fd_sc_hd__mux2_1
XFILLER_0_54_96 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_49_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2015_ clknet_leaf_20_clk _0155_ VGND VGND VPWR VPWR net79 sky130_fd_sc_hd__dfxtp_1
XFILLER_0_57_182 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_45_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_9_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_9_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold142 data\[3\]\[44\] VGND VGND VPWR VPWR net293 sky130_fd_sc_hd__dlygate4sd3_1
Xhold197 data\[0\]\[27\] VGND VGND VPWR VPWR net348 sky130_fd_sc_hd__dlygate4sd3_1
Xhold164 data\[3\]\[47\] VGND VGND VPWR VPWR net315 sky130_fd_sc_hd__dlygate4sd3_1
Xhold186 data\[0\]\[25\] VGND VGND VPWR VPWR net337 sky130_fd_sc_hd__dlygate4sd3_1
Xhold153 data\[2\]\[70\] VGND VGND VPWR VPWR net304 sky130_fd_sc_hd__dlygate4sd3_1
Xhold175 data\[2\]\[1\] VGND VGND VPWR VPWR net326 sky130_fd_sc_hd__dlygate4sd3_1
Xhold120 data\[2\]\[69\] VGND VGND VPWR VPWR net271 sky130_fd_sc_hd__dlygate4sd3_1
Xhold131 data\[0\]\[4\] VGND VGND VPWR VPWR net282 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_56_501 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_54_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_6_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_0963_ _0797_ VGND VGND VPWR VPWR _0798_ sky130_fd_sc_hd__buf_4
XFILLER_0_49_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1515_ _0589_ VGND VGND VPWR VPWR _0196_ sky130_fd_sc_hd__clkbuf_1
X_1446_ _0778_ VGND VGND VPWR VPWR _0553_ sky130_fd_sc_hd__buf_4
X_1377_ net294 _0411_ _0507_ VGND VGND VPWR VPWR _0517_ sky130_fd_sc_hd__mux2_1
XFILLER_0_37_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_5_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_271 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_51_122 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_51_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_24_336 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_24_294 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_51_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_24_Left_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1300_ net423 _0856_ _0474_ VGND VGND VPWR VPWR _0477_ sky130_fd_sc_hd__mux2_1
XFILLER_0_35_10 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1162_ net335 _0381_ _0382_ VGND VGND VPWR VPWR _0383_ sky130_fd_sc_hd__mux2_1
X_1231_ _0435_ VGND VGND VPWR VPWR _0066_ sky130_fd_sc_hd__clkbuf_1
X_1093_ net32 _0898_ _0882_ VGND VGND VPWR VPWR _0899_ sky130_fd_sc_hd__mux2_1
XFILLER_0_42_155 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1995_ clknet_leaf_30_clk _0135_ VGND VGND VPWR VPWR data\[0\]\[63\] sky130_fd_sc_hd__dfxtp_1
X_0946_ data\[0\]\[2\] data\[1\]\[2\] data\[2\]\[2\] data\[3\]\[2\] _0771_ _0772_
+ VGND VGND VPWR VPWR _0785_ sky130_fd_sc_hd__mux4_1
XFILLER_0_55_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1429_ _0544_ VGND VGND VPWR VPWR _0155_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_38_386 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_18_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_21_275 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1780_ _0729_ VGND VGND VPWR VPWR _0321_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_12_220 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_41_9 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2194_ clknet_leaf_5_clk _0334_ VGND VGND VPWR VPWR data\[1\]\[46\] sky130_fd_sc_hd__dfxtp_1
X_1145_ data\[0\]\[47\] data\[1\]\[47\] data\[2\]\[47\] data\[3\]\[47\] _0365_ _0908_
+ VGND VGND VPWR VPWR _0369_ sky130_fd_sc_hd__mux4_1
X_1214_ net179 _0422_ _0416_ VGND VGND VPWR VPWR _0423_ sky130_fd_sc_hd__mux2_1
XFILLER_0_1_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_62_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_62_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_62_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1076_ data\[0\]\[31\] data\[1\]\[31\] data\[2\]\[31\] data\[3\]\[31\] _0867_ _0874_
+ VGND VGND VPWR VPWR _0886_ sky130_fd_sc_hd__mux4_1
XFILLER_0_47_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_47_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_35_367 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_7_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_15_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1978_ clknet_leaf_5_clk _0118_ VGND VGND VPWR VPWR data\[0\]\[46\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_15_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xhold57 data\[1\]\[44\] VGND VGND VPWR VPWR net208 sky130_fd_sc_hd__dlygate4sd3_1
Xhold46 data\[2\]\[42\] VGND VGND VPWR VPWR net197 sky130_fd_sc_hd__dlygate4sd3_1
Xhold13 data\[3\]\[28\] VGND VGND VPWR VPWR net164 sky130_fd_sc_hd__dlygate4sd3_1
Xhold79 data\[2\]\[5\] VGND VGND VPWR VPWR net230 sky130_fd_sc_hd__dlygate4sd3_1
Xhold35 data\[2\]\[14\] VGND VGND VPWR VPWR net186 sky130_fd_sc_hd__dlygate4sd3_1
Xhold68 data\[1\]\[60\] VGND VGND VPWR VPWR net219 sky130_fd_sc_hd__dlygate4sd3_1
Xhold24 data\[1\]\[58\] VGND VGND VPWR VPWR net175 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_49_459 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1901_ clknet_leaf_3_clk _0041_ VGND VGND VPWR VPWR data\[2\]\[41\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_32_348 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_29_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1832_ _0756_ VGND VGND VPWR VPWR _0346_ sky130_fd_sc_hd__clkbuf_1
X_1763_ _0720_ VGND VGND VPWR VPWR _0313_ sky130_fd_sc_hd__clkbuf_1
X_1694_ net334 _0431_ _0678_ VGND VGND VPWR VPWR _0684_ sky130_fd_sc_hd__mux2_1
XFILLER_0_57_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_27_Left_92 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1128_ data\[0\]\[43\] data\[1\]\[43\] data\[2\]\[43\] data\[3\]\[43\] _0901_ _0908_
+ VGND VGND VPWR VPWR _0926_ sky130_fd_sc_hd__mux4_1
X_2177_ clknet_leaf_13_clk _0317_ VGND VGND VPWR VPWR data\[1\]\[29\] sky130_fd_sc_hd__dfxtp_1
X_1059_ net443 _0872_ _0850_ VGND VGND VPWR VPWR _0873_ sky130_fd_sc_hd__mux2_1
XPHY_EDGE_ROW_11_Left_76 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_18_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_58_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_34_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_1_317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2100_ clknet_leaf_16_clk _0240_ VGND VGND VPWR VPWR data\[3\]\[24\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_27_44 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2031_ clknet_leaf_14_clk _0171_ VGND VGND VPWR VPWR net96 sky130_fd_sc_hd__dfxtp_1
XFILLER_0_27_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1815_ net266 _0381_ _0747_ VGND VGND VPWR VPWR _0748_ sky130_fd_sc_hd__mux2_1
XFILLER_0_4_122 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_17_239 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold313 net98 VGND VGND VPWR VPWR net464 sky130_fd_sc_hd__dlygate4sd3_1
Xhold346 net100 VGND VGND VPWR VPWR net497 sky130_fd_sc_hd__dlygate4sd3_1
Xhold335 net93 VGND VGND VPWR VPWR net486 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_40_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold302 data\[0\]\[56\] VGND VGND VPWR VPWR net453 sky130_fd_sc_hd__dlygate4sd3_1
X_1677_ net383 _0404_ _0667_ VGND VGND VPWR VPWR _0675_ sky130_fd_sc_hd__mux2_1
XFILLER_0_0_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold324 net147 VGND VGND VPWR VPWR net475 sky130_fd_sc_hd__dlygate4sd3_1
X_1746_ _0711_ VGND VGND VPWR VPWR _0305_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_59_521 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_31_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_7_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_58_128 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_39_320 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_42_410 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_14_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1462_ _0561_ VGND VGND VPWR VPWR _0171_ sky130_fd_sc_hd__clkbuf_1
X_1600_ net160 _0849_ _0634_ VGND VGND VPWR VPWR _0635_ sky130_fd_sc_hd__mux2_1
XFILLER_0_1_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1531_ net457 _0413_ _0597_ VGND VGND VPWR VPWR _0598_ sky130_fd_sc_hd__mux2_1
XFILLER_0_22_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_22_286 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1393_ _0525_ VGND VGND VPWR VPWR _0138_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_54_64 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_9_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2014_ clknet_leaf_20_clk _0154_ VGND VGND VPWR VPWR net78 sky130_fd_sc_hd__dfxtp_1
Xhold110 data\[3\]\[32\] VGND VGND VPWR VPWR net261 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_45_356 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xhold132 data\[3\]\[35\] VGND VGND VPWR VPWR net283 sky130_fd_sc_hd__dlygate4sd3_1
Xhold121 data\[2\]\[47\] VGND VGND VPWR VPWR net272 sky130_fd_sc_hd__dlygate4sd3_1
Xhold198 data\[1\]\[48\] VGND VGND VPWR VPWR net349 sky130_fd_sc_hd__dlygate4sd3_1
Xhold165 data\[2\]\[34\] VGND VGND VPWR VPWR net316 sky130_fd_sc_hd__dlygate4sd3_1
Xhold154 data\[3\]\[54\] VGND VGND VPWR VPWR net305 sky130_fd_sc_hd__dlygate4sd3_1
Xhold176 data\[0\]\[50\] VGND VGND VPWR VPWR net327 sky130_fd_sc_hd__dlygate4sd3_1
Xhold143 data\[0\]\[59\] VGND VGND VPWR VPWR net294 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_13_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1729_ _0702_ VGND VGND VPWR VPWR _0297_ sky130_fd_sc_hd__clkbuf_1
Xhold187 data\[3\]\[67\] VGND VGND VPWR VPWR net338 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_56_502 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_8_291 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_24_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_54_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_0962_ net1 VGND VGND VPWR VPWR _0797_ sky130_fd_sc_hd__buf_4
XFILLER_0_27_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1514_ net502 _0387_ _0586_ VGND VGND VPWR VPWR _0589_ sky130_fd_sc_hd__mux2_1
X_1445_ _0552_ VGND VGND VPWR VPWR _0163_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_2_149 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1376_ _0516_ VGND VGND VPWR VPWR _0130_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_60_156 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_60_112 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_45_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_5_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_51_156 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_51_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_24_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_24_295 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_10_58 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1092_ data\[0\]\[35\] data\[1\]\[35\] data\[2\]\[35\] data\[3\]\[35\] _0867_ _0874_
+ VGND VGND VPWR VPWR _0898_ sky130_fd_sc_hd__mux4_1
X_1161_ net149 VGND VGND VPWR VPWR _0382_ sky130_fd_sc_hd__buf_4
X_1230_ net356 _0434_ _0416_ VGND VGND VPWR VPWR _0435_ sky130_fd_sc_hd__mux2_1
XFILLER_0_59_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1994_ clknet_leaf_27_clk _0134_ VGND VGND VPWR VPWR data\[0\]\[62\] sky130_fd_sc_hd__dfxtp_1
X_0945_ _0784_ VGND VGND VPWR VPWR _0001_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_15_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_48_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1428_ net452 _0818_ _0542_ VGND VGND VPWR VPWR _0544_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_38_387 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1359_ net327 _0381_ _0507_ VGND VGND VPWR VPWR _0508_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_21_276 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_33_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_46_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1213_ net62 _0421_ _0414_ VGND VGND VPWR VPWR _0422_ sky130_fd_sc_hd__mux2_1
X_2193_ clknet_leaf_7_clk _0333_ VGND VGND VPWR VPWR data\[1\]\[45\] sky130_fd_sc_hd__dfxtp_1
X_1144_ _0368_ VGND VGND VPWR VPWR _0046_ sky130_fd_sc_hd__clkbuf_1
X_1075_ _0885_ VGND VGND VPWR VPWR _0030_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_62_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1977_ clknet_leaf_9_clk _0117_ VGND VGND VPWR VPWR data\[0\]\[45\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_35_368 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_15_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold47 data\[0\]\[31\] VGND VGND VPWR VPWR net198 sky130_fd_sc_hd__dlygate4sd3_1
Xhold14 data\[3\]\[45\] VGND VGND VPWR VPWR net165 sky130_fd_sc_hd__dlygate4sd3_1
Xhold69 data\[1\]\[4\] VGND VGND VPWR VPWR net220 sky130_fd_sc_hd__dlygate4sd3_1
Xhold58 data\[2\]\[18\] VGND VGND VPWR VPWR net209 sky130_fd_sc_hd__dlygate4sd3_1
Xhold25 data\[1\]\[62\] VGND VGND VPWR VPWR net176 sky130_fd_sc_hd__dlygate4sd3_1
Xhold36 data\[3\]\[5\] VGND VGND VPWR VPWR net187 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_29_204 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_16_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1900_ clknet_leaf_5_clk _0040_ VGND VGND VPWR VPWR data\[2\]\[40\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_32_349 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_32_12 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_4_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1831_ net175 _0408_ _0747_ VGND VGND VPWR VPWR _0756_ sky130_fd_sc_hd__mux2_1
XFILLER_0_52_262 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1762_ net418 _0865_ _0714_ VGND VGND VPWR VPWR _0720_ sky130_fd_sc_hd__mux2_1
X_1693_ _0683_ VGND VGND VPWR VPWR _0280_ sky130_fd_sc_hd__clkbuf_1
X_2176_ clknet_leaf_11_clk _0316_ VGND VGND VPWR VPWR data\[1\]\[28\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_32_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1127_ _0925_ VGND VGND VPWR VPWR _0042_ sky130_fd_sc_hd__clkbuf_1
X_1058_ net23 _0871_ _0848_ VGND VGND VPWR VPWR _0872_ sky130_fd_sc_hd__mux2_1
XFILLER_0_43_262 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_3_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_1_Right_1 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_19_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2030_ clknet_leaf_14_clk _0170_ VGND VGND VPWR VPWR net95 sky130_fd_sc_hd__dfxtp_1
XFILLER_0_27_12 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_45_430 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_57_376 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1814_ net150 VGND VGND VPWR VPWR _0747_ sky130_fd_sc_hd__buf_4
X_1745_ net171 _0838_ _0703_ VGND VGND VPWR VPWR _0711_ sky130_fd_sc_hd__mux2_1
Xhold303 net107 VGND VGND VPWR VPWR net454 sky130_fd_sc_hd__dlygate4sd3_1
Xhold336 net112 VGND VGND VPWR VPWR net487 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_40_298 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold347 net94 VGND VGND VPWR VPWR net498 sky130_fd_sc_hd__dlygate4sd3_1
X_1676_ _0674_ VGND VGND VPWR VPWR _0272_ sky130_fd_sc_hd__clkbuf_1
Xhold325 net84 VGND VGND VPWR VPWR net476 sky130_fd_sc_hd__dlygate4sd3_1
Xhold314 net80 VGND VGND VPWR VPWR net465 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_30_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2159_ clknet_leaf_21_clk _0299_ VGND VGND VPWR VPWR data\[1\]\[11\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_63_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_48_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_16_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_59_522 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_8_188 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_42_411 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_leaf_24_clk clknet_2_2__leaf_clk VGND VGND VPWR VPWR clknet_leaf_24_clk sky130_fd_sc_hd__clkbuf_8
X_1461_ net440 _0871_ _0553_ VGND VGND VPWR VPWR _0561_ sky130_fd_sc_hd__mux2_1
XFILLER_0_1_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1392_ net360 _0434_ _0518_ VGND VGND VPWR VPWR _0525_ sky130_fd_sc_hd__mux2_1
X_1530_ _0778_ VGND VGND VPWR VPWR _0597_ sky130_fd_sc_hd__buf_4
X_2013_ clknet_leaf_24_clk _0153_ VGND VGND VPWR VPWR net148 sky130_fd_sc_hd__dfxtp_1
XFILLER_0_45_346 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_leaf_15_clk clknet_2_3__leaf_clk VGND VGND VPWR VPWR clknet_leaf_15_clk sky130_fd_sc_hd__clkbuf_8
Xhold100 data\[1\]\[18\] VGND VGND VPWR VPWR net251 sky130_fd_sc_hd__dlygate4sd3_1
Xhold122 data\[0\]\[18\] VGND VGND VPWR VPWR net273 sky130_fd_sc_hd__dlygate4sd3_1
Xhold144 data\[3\]\[6\] VGND VGND VPWR VPWR net295 sky130_fd_sc_hd__dlygate4sd3_1
X_1728_ net258 _0811_ _0692_ VGND VGND VPWR VPWR _0702_ sky130_fd_sc_hd__mux2_1
Xhold111 data\[3\]\[2\] VGND VGND VPWR VPWR net262 sky130_fd_sc_hd__dlygate4sd3_1
Xhold133 data\[1\]\[57\] VGND VGND VPWR VPWR net284 sky130_fd_sc_hd__dlygate4sd3_1
Xhold177 data\[3\]\[29\] VGND VGND VPWR VPWR net328 sky130_fd_sc_hd__dlygate4sd3_1
Xhold166 data\[2\]\[46\] VGND VGND VPWR VPWR net317 sky130_fd_sc_hd__dlygate4sd3_1
X_1659_ _0665_ VGND VGND VPWR VPWR _0264_ sky130_fd_sc_hd__clkbuf_1
Xhold188 data\[3\]\[25\] VGND VGND VPWR VPWR net339 sky130_fd_sc_hd__dlygate4sd3_1
Xhold155 data\[2\]\[52\] VGND VGND VPWR VPWR net306 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_5_169 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xhold199 data\[1\]\[69\] VGND VGND VPWR VPWR net350 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_56_503 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_51_327 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_48_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_62_539 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_27_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_0961_ _0796_ VGND VGND VPWR VPWR _0005_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_54_176 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_54_154 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_49_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xclkbuf_leaf_4_clk clknet_2_1__leaf_clk VGND VGND VPWR VPWR clknet_leaf_4_clk sky130_fd_sc_hd__clkbuf_8
X_1513_ _0588_ VGND VGND VPWR VPWR _0195_ sky130_fd_sc_hd__clkbuf_1
X_1444_ net503 _0844_ _0542_ VGND VGND VPWR VPWR _0552_ sky130_fd_sc_hd__mux2_1
XFILLER_0_10_224 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1375_ net392 _0408_ _0507_ VGND VGND VPWR VPWR _0516_ sky130_fd_sc_hd__mux2_1
XFILLER_0_60_102 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_5_240 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_60_124 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_51_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_24_296 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_10_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_32_382 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1091_ _0897_ VGND VGND VPWR VPWR _0034_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_35_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1160_ net49 _0379_ _0380_ VGND VGND VPWR VPWR _0381_ sky130_fd_sc_hd__mux2_1
XFILLER_0_51_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_0944_ net326 _0783_ _0780_ VGND VGND VPWR VPWR _0784_ sky130_fd_sc_hd__mux2_1
X_1993_ clknet_leaf_27_clk _0133_ VGND VGND VPWR VPWR data\[0\]\[61\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_50_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_42_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1358_ _0451_ VGND VGND VPWR VPWR _0507_ sky130_fd_sc_hd__buf_4
X_1427_ _0543_ VGND VGND VPWR VPWR _0154_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_38_388 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_18_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1289_ net372 _0838_ _0463_ VGND VGND VPWR VPWR _0471_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_21_277 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_21_319 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_21_14 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_24_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_24_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2192_ clknet_leaf_6_clk _0332_ VGND VGND VPWR VPWR data\[1\]\[44\] sky130_fd_sc_hd__dfxtp_1
X_1212_ data\[0\]\[62\] data\[1\]\[62\] data\[2\]\[62\] data\[3\]\[62\] _0399_ _0406_
+ VGND VGND VPWR VPWR _0421_ sky130_fd_sc_hd__mux4_1
X_1143_ net317 _0367_ _0918_ VGND VGND VPWR VPWR _0368_ sky130_fd_sc_hd__mux2_1
X_1074_ net218 _0883_ _0884_ VGND VGND VPWR VPWR _0885_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_35_369 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_1_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1976_ clknet_leaf_6_clk _0116_ VGND VGND VPWR VPWR data\[0\]\[44\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_15_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_15_146 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_60_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold15 data\[2\]\[45\] VGND VGND VPWR VPWR net166 sky130_fd_sc_hd__dlygate4sd3_1
Xhold26 data\[3\]\[21\] VGND VGND VPWR VPWR net177 sky130_fd_sc_hd__dlygate4sd3_1
Xhold59 data\[3\]\[18\] VGND VGND VPWR VPWR net210 sky130_fd_sc_hd__dlygate4sd3_1
Xhold48 data\[3\]\[10\] VGND VGND VPWR VPWR net199 sky130_fd_sc_hd__dlygate4sd3_1
Xhold37 data\[2\]\[10\] VGND VGND VPWR VPWR net188 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_61_252 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_21_116 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_29_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1761_ _0719_ VGND VGND VPWR VPWR _0312_ sky130_fd_sc_hd__clkbuf_1
X_1830_ _0755_ VGND VGND VPWR VPWR _0345_ sky130_fd_sc_hd__clkbuf_1
X_1692_ net158 _0428_ _0678_ VGND VGND VPWR VPWR _0683_ sky130_fd_sc_hd__mux2_1
XFILLER_0_12_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1126_ net197 _0924_ _0918_ VGND VGND VPWR VPWR _0925_ sky130_fd_sc_hd__mux2_1
X_2175_ clknet_leaf_14_clk _0315_ VGND VGND VPWR VPWR data\[1\]\[27\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_48_450 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1057_ data\[0\]\[27\] data\[1\]\[27\] data\[2\]\[27\] data\[3\]\[27\] _0867_ _0840_
+ VGND VGND VPWR VPWR _0871_ sky130_fd_sc_hd__mux4_1
X_1959_ clknet_leaf_14_clk _0099_ VGND VGND VPWR VPWR data\[0\]\[27\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_43_274 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_28_282 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_19_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_57_344 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_57_311 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_45_431 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_0_clk clk VGND VGND VPWR VPWR clknet_0_clk sky130_fd_sc_hd__clkbuf_16
Xhold326 net106 VGND VGND VPWR VPWR net477 sky130_fd_sc_hd__dlygate4sd3_1
X_1813_ _0746_ VGND VGND VPWR VPWR _0337_ sky130_fd_sc_hd__clkbuf_1
X_1744_ _0710_ VGND VGND VPWR VPWR _0304_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_25_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_4_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold304 net135 VGND VGND VPWR VPWR net455 sky130_fd_sc_hd__dlygate4sd3_1
Xhold315 net88 VGND VGND VPWR VPWR net466 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_40_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1675_ net398 _0401_ _0667_ VGND VGND VPWR VPWR _0674_ sky130_fd_sc_hd__mux2_1
Xhold348 net130 VGND VGND VPWR VPWR net499 sky130_fd_sc_hd__dlygate4sd3_1
XPHY_EDGE_ROW_15_Right_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold337 net121 VGND VGND VPWR VPWR net488 sky130_fd_sc_hd__dlygate4sd3_1
X_1109_ _0911_ VGND VGND VPWR VPWR _0038_ sky130_fd_sc_hd__clkbuf_1
XPHY_EDGE_ROW_24_Right_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2158_ clknet_leaf_20_clk _0298_ VGND VGND VPWR VPWR data\[1\]\[10\] sky130_fd_sc_hd__dfxtp_1
X_2089_ clknet_leaf_20_clk _0229_ VGND VGND VPWR VPWR data\[3\]\[13\] sky130_fd_sc_hd__dfxtp_1
XPHY_EDGE_ROW_33_Right_33 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_59_523 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_8_189 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_42_Right_42 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_42_412 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_13_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_51_Right_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_1_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1460_ _0560_ VGND VGND VPWR VPWR _0170_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_38_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_1_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1391_ _0524_ VGND VGND VPWR VPWR _0137_ sky130_fd_sc_hd__clkbuf_1
XPHY_EDGE_ROW_60_Right_60 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_35_Left_100 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2012_ clknet_leaf_24_clk _0152_ VGND VGND VPWR VPWR net147 sky130_fd_sc_hd__dfxtp_1
Xhold156 data\[0\]\[36\] VGND VGND VPWR VPWR net307 sky130_fd_sc_hd__dlygate4sd3_1
Xhold134 data\[3\]\[46\] VGND VGND VPWR VPWR net285 sky130_fd_sc_hd__dlygate4sd3_1
Xhold167 data\[2\]\[33\] VGND VGND VPWR VPWR net318 sky130_fd_sc_hd__dlygate4sd3_1
Xhold123 data\[3\]\[30\] VGND VGND VPWR VPWR net274 sky130_fd_sc_hd__dlygate4sd3_1
X_1658_ net376 _0374_ _0656_ VGND VGND VPWR VPWR _0665_ sky130_fd_sc_hd__mux2_1
Xhold112 data\[3\]\[70\] VGND VGND VPWR VPWR net263 sky130_fd_sc_hd__dlygate4sd3_1
X_1727_ _0701_ VGND VGND VPWR VPWR _0296_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_13_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold101 data\[1\]\[68\] VGND VGND VPWR VPWR net252 sky130_fd_sc_hd__dlygate4sd3_1
Xhold145 data\[1\]\[5\] VGND VGND VPWR VPWR net296 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_56_504 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xhold189 data\[1\]\[59\] VGND VGND VPWR VPWR net340 sky130_fd_sc_hd__dlygate4sd3_1
Xhold178 data\[0\]\[71\] VGND VGND VPWR VPWR net329 sky130_fd_sc_hd__dlygate4sd3_1
X_1589_ net248 _0831_ _0623_ VGND VGND VPWR VPWR _0629_ sky130_fd_sc_hd__mux2_1
XFILLER_0_48_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_63_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_48_174 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_24_14 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_39_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_0960_ net230 _0795_ _0780_ VGND VGND VPWR VPWR _0796_ sky130_fd_sc_hd__mux2_1
XFILLER_0_24_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_49_33 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1512_ net123 _0384_ _0586_ VGND VGND VPWR VPWR _0588_ sky130_fd_sc_hd__mux2_1
X_1443_ _0551_ VGND VGND VPWR VPWR _0162_ sky130_fd_sc_hd__clkbuf_1
X_1374_ _0515_ VGND VGND VPWR VPWR _0129_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_51_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_36_166 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_24_297 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_19_14 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_59_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1090_ net316 _0896_ _0884_ VGND VGND VPWR VPWR _0897_ sky130_fd_sc_hd__mux2_1
XFILLER_0_35_79 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_35_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_27_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_0943_ net15 _0782_ _0775_ VGND VGND VPWR VPWR _0783_ sky130_fd_sc_hd__mux2_1
X_1992_ clknet_leaf_28_clk _0132_ VGND VGND VPWR VPWR data\[0\]\[60\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_15_328 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_50_180 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_2_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1357_ _0506_ VGND VGND VPWR VPWR _0121_ sky130_fd_sc_hd__clkbuf_1
X_1288_ _0470_ VGND VGND VPWR VPWR _0088_ sky130_fd_sc_hd__clkbuf_1
X_1426_ net500 _0813_ _0542_ VGND VGND VPWR VPWR _0543_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_38_389 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_18_100 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_21_278 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_64_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2191_ clknet_leaf_6_clk _0331_ VGND VGND VPWR VPWR data\[1\]\[43\] sky130_fd_sc_hd__dfxtp_1
X_1142_ net44 _0366_ _0916_ VGND VGND VPWR VPWR _0367_ sky130_fd_sc_hd__mux2_1
X_1211_ _0420_ VGND VGND VPWR VPWR _0061_ sky130_fd_sc_hd__clkbuf_1
X_1073_ net149 VGND VGND VPWR VPWR _0884_ sky130_fd_sc_hd__buf_4
XFILLER_0_1_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1975_ clknet_leaf_6_clk _0115_ VGND VGND VPWR VPWR data\[0\]\[43\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_53_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold16 data\[3\]\[52\] VGND VGND VPWR VPWR net167 sky130_fd_sc_hd__dlygate4sd3_1
Xhold27 data\[3\]\[50\] VGND VGND VPWR VPWR net178 sky130_fd_sc_hd__dlygate4sd3_1
Xhold38 data\[2\]\[61\] VGND VGND VPWR VPWR net189 sky130_fd_sc_hd__dlygate4sd3_1
X_1409_ net483 _0785_ _0531_ VGND VGND VPWR VPWR _0534_ sky130_fd_sc_hd__mux2_1
Xhold49 data\[3\]\[17\] VGND VGND VPWR VPWR net200 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_14_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_37_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1760_ net342 _0862_ _0714_ VGND VGND VPWR VPWR _0719_ sky130_fd_sc_hd__mux2_1
XFILLER_0_12_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1691_ _0682_ VGND VGND VPWR VPWR _0279_ sky130_fd_sc_hd__clkbuf_1
X_1125_ net40 _0923_ _0916_ VGND VGND VPWR VPWR _0924_ sky130_fd_sc_hd__mux2_1
XFILLER_0_57_99 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2174_ clknet_leaf_13_clk _0314_ VGND VGND VPWR VPWR data\[1\]\[26\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_48_451 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1056_ _0870_ VGND VGND VPWR VPWR _0026_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_31_340 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_28_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_7_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_7_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1958_ clknet_leaf_14_clk _0098_ VGND VGND VPWR VPWR data\[0\]\[26\] sky130_fd_sc_hd__dfxtp_1
X_1889_ clknet_leaf_13_clk _0029_ VGND VGND VPWR VPWR data\[2\]\[29\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_3_361 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_54_487 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_57_356 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_57_323 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_45_432 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_43_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold316 net117 VGND VGND VPWR VPWR net467 sky130_fd_sc_hd__dlygate4sd3_1
X_1812_ net322 _0377_ _0736_ VGND VGND VPWR VPWR _0746_ sky130_fd_sc_hd__mux2_1
X_1674_ _0673_ VGND VGND VPWR VPWR _0271_ sky130_fd_sc_hd__clkbuf_1
Xhold338 net145 VGND VGND VPWR VPWR net489 sky130_fd_sc_hd__dlygate4sd3_1
X_1743_ net222 _0835_ _0703_ VGND VGND VPWR VPWR _0710_ sky130_fd_sc_hd__mux2_1
XFILLER_0_25_231 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold305 net77 VGND VGND VPWR VPWR net456 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_7_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xhold327 net132 VGND VGND VPWR VPWR net478 sky130_fd_sc_hd__dlygate4sd3_1
Xhold349 net78 VGND VGND VPWR VPWR net500 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_48_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1039_ _0857_ VGND VGND VPWR VPWR _0022_ sky130_fd_sc_hd__clkbuf_1
X_1108_ net345 _0910_ _0884_ VGND VGND VPWR VPWR _0911_ sky130_fd_sc_hd__mux2_1
X_2088_ clknet_leaf_24_clk _0228_ VGND VGND VPWR VPWR data\[3\]\[12\] sky130_fd_sc_hd__dfxtp_1
X_2157_ clknet_leaf_24_clk _0297_ VGND VGND VPWR VPWR data\[1\]\[9\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_63_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_51_468 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_16_264 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_59_524 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_54_326 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_54_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_42_413 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_54_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_38_13 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1390_ net377 _0431_ _0518_ VGND VGND VPWR VPWR _0524_ sky130_fd_sc_hd__mux2_1
XFILLER_0_54_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2011_ clknet_leaf_22_clk _0151_ VGND VGND VPWR VPWR net146 sky130_fd_sc_hd__dfxtp_1
XFILLER_0_60_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_45_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xhold179 data\[2\]\[35\] VGND VGND VPWR VPWR net330 sky130_fd_sc_hd__dlygate4sd3_1
Xhold124 data\[1\]\[40\] VGND VGND VPWR VPWR net275 sky130_fd_sc_hd__dlygate4sd3_1
X_1657_ _0664_ VGND VGND VPWR VPWR _0263_ sky130_fd_sc_hd__clkbuf_1
Xhold113 data\[2\]\[49\] VGND VGND VPWR VPWR net264 sky130_fd_sc_hd__dlygate4sd3_1
Xhold102 data\[3\]\[49\] VGND VGND VPWR VPWR net253 sky130_fd_sc_hd__dlygate4sd3_1
Xhold135 data\[1\]\[3\] VGND VGND VPWR VPWR net286 sky130_fd_sc_hd__dlygate4sd3_1
Xhold168 data\[0\]\[62\] VGND VGND VPWR VPWR net319 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_0_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1726_ net308 _0808_ _0692_ VGND VGND VPWR VPWR _0701_ sky130_fd_sc_hd__mux2_1
X_1588_ _0628_ VGND VGND VPWR VPWR _0230_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_13_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold157 data\[1\]\[8\] VGND VGND VPWR VPWR net308 sky130_fd_sc_hd__dlygate4sd3_1
Xhold146 data\[3\]\[12\] VGND VGND VPWR VPWR net297 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_56_505 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2209_ clknet_leaf_28_clk _0349_ VGND VGND VPWR VPWR data\[1\]\[61\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_0_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_64_560 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_63_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_48_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_8_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_5_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_2_0__f_clk clknet_0_clk VGND VGND VPWR VPWR clknet_2_0__leaf_clk sky130_fd_sc_hd__clkbuf_16
XFILLER_0_42_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_27_348 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1442_ net462 _0841_ _0542_ VGND VGND VPWR VPWR _0551_ sky130_fd_sc_hd__mux2_1
X_1511_ _0587_ VGND VGND VPWR VPWR _0194_ sky130_fd_sc_hd__clkbuf_1
X_1373_ net424 _0404_ _0507_ VGND VGND VPWR VPWR _0515_ sky130_fd_sc_hd__mux2_1
XFILLER_0_41_351 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_41_340 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_5_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_231 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1709_ _0691_ VGND VGND VPWR VPWR _0692_ sky130_fd_sc_hd__buf_4
XPHY_EDGE_ROW_18_Left_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_54_Left_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_36_178 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_24_298 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_63_Left_128 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_59_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_35_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_51_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_27_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_27_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_2_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_0942_ data\[0\]\[1\] data\[1\]\[1\] data\[2\]\[1\] data\[3\]\[1\] _0771_ _0772_
+ VGND VGND VPWR VPWR _0782_ sky130_fd_sc_hd__mux4_1
X_1991_ clknet_leaf_1_clk _0131_ VGND VGND VPWR VPWR data\[0\]\[59\] sky130_fd_sc_hd__dfxtp_1
X_1425_ _0778_ VGND VGND VPWR VPWR _0542_ sky130_fd_sc_hd__buf_4
X_1356_ net363 _0377_ _0496_ VGND VGND VPWR VPWR _0506_ sky130_fd_sc_hd__mux2_1
X_1287_ net216 _0835_ _0463_ VGND VGND VPWR VPWR _0470_ sky130_fd_sc_hd__mux2_1
XPHY_EDGE_ROW_3_Left_68 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_49_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_24_115 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_32_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_20_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2190_ clknet_leaf_7_clk _0330_ VGND VGND VPWR VPWR data\[1\]\[42\] sky130_fd_sc_hd__dfxtp_1
X_1141_ data\[0\]\[46\] data\[1\]\[46\] data\[2\]\[46\] data\[3\]\[46\] _0365_ _0908_
+ VGND VGND VPWR VPWR _0366_ sky130_fd_sc_hd__mux4_1
XFILLER_0_46_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_46_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1072_ net27 _0881_ _0882_ VGND VGND VPWR VPWR _0883_ sky130_fd_sc_hd__mux2_1
X_1210_ net189 _0419_ _0416_ VGND VGND VPWR VPWR _0420_ sky130_fd_sc_hd__mux2_1
XFILLER_0_1_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1974_ clknet_leaf_8_clk _0114_ VGND VGND VPWR VPWR data\[0\]\[42\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_7_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_126 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_15_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold17 data\[0\]\[7\] VGND VGND VPWR VPWR net168 sky130_fd_sc_hd__dlygate4sd3_1
Xhold28 data\[2\]\[62\] VGND VGND VPWR VPWR net179 sky130_fd_sc_hd__dlygate4sd3_1
X_1408_ _0533_ VGND VGND VPWR VPWR _0145_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_11_343 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_11_376 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold39 data\[2\]\[9\] VGND VGND VPWR VPWR net190 sky130_fd_sc_hd__dlygate4sd3_1
X_1339_ _0497_ VGND VGND VPWR VPWR _0112_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_26_305 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_46_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_34_360 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_16_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_32_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_40_396 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1690_ net207 _0425_ _0678_ VGND VGND VPWR VPWR _0682_ sky130_fd_sc_hd__mux2_1
XFILLER_0_57_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_57_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1124_ data\[0\]\[42\] data\[1\]\[42\] data\[2\]\[42\] data\[3\]\[42\] _0901_ _0908_
+ VGND VGND VPWR VPWR _0923_ sky130_fd_sc_hd__mux4_1
X_1055_ net172 _0869_ _0850_ VGND VGND VPWR VPWR _0870_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_48_452 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2173_ clknet_leaf_19_clk _0313_ VGND VGND VPWR VPWR data\[1\]\[25\] sky130_fd_sc_hd__dfxtp_1
X_1957_ clknet_leaf_16_clk _0097_ VGND VGND VPWR VPWR data\[0\]\[25\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_31_341 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_7_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1888_ clknet_leaf_11_clk _0028_ VGND VGND VPWR VPWR data\[2\]\[28\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_43_254 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_3_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_54_488 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_45_433 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_leaf_27_clk clknet_2_0__leaf_clk VGND VGND VPWR VPWR clknet_leaf_27_clk sky130_fd_sc_hd__clkbuf_8
XPHY_EDGE_ROW_6_Left_71 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_57_368 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_57_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1811_ _0745_ VGND VGND VPWR VPWR _0336_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_4_115 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xhold328 net118 VGND VGND VPWR VPWR net479 sky130_fd_sc_hd__dlygate4sd3_1
X_1673_ net267 _0397_ _0667_ VGND VGND VPWR VPWR _0673_ sky130_fd_sc_hd__mux2_1
XFILLER_0_25_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_0_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold317 net134 VGND VGND VPWR VPWR net468 sky130_fd_sc_hd__dlygate4sd3_1
Xhold306 net133 VGND VGND VPWR VPWR net457 sky130_fd_sc_hd__dlygate4sd3_1
X_1742_ _0709_ VGND VGND VPWR VPWR _0303_ sky130_fd_sc_hd__clkbuf_1
Xhold339 net148 VGND VGND VPWR VPWR net490 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_0_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_48_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1038_ net321 _0856_ _0850_ VGND VGND VPWR VPWR _0857_ sky130_fd_sc_hd__mux2_1
X_1107_ net35 _0909_ _0882_ VGND VGND VPWR VPWR _0910_ sky130_fd_sc_hd__mux2_1
Xclkbuf_leaf_18_clk clknet_2_2__leaf_clk VGND VGND VPWR VPWR clknet_leaf_18_clk sky130_fd_sc_hd__clkbuf_8
XPHY_EDGE_ROW_5_Right_5 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2156_ clknet_leaf_23_clk _0296_ VGND VGND VPWR VPWR data\[1\]\[8\] sky130_fd_sc_hd__dfxtp_1
X_2087_ clknet_leaf_21_clk _0227_ VGND VGND VPWR VPWR data\[3\]\[11\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_17_70 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_63_349 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_63_305 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_51_469 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_31_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_59_525 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_42_414 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_32_Left_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2010_ clknet_leaf_22_clk _0150_ VGND VGND VPWR VPWR net143 sky130_fd_sc_hd__dfxtp_1
XFILLER_0_54_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_53_382 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1725_ _0700_ VGND VGND VPWR VPWR _0295_ sky130_fd_sc_hd__clkbuf_1
Xclkbuf_leaf_7_clk clknet_2_1__leaf_clk VGND VGND VPWR VPWR clknet_leaf_7_clk sky130_fd_sc_hd__clkbuf_8
X_1656_ net315 _0370_ _0656_ VGND VGND VPWR VPWR _0664_ sky130_fd_sc_hd__mux2_1
Xhold169 data\[1\]\[23\] VGND VGND VPWR VPWR net320 sky130_fd_sc_hd__dlygate4sd3_1
Xhold125 data\[1\]\[55\] VGND VGND VPWR VPWR net276 sky130_fd_sc_hd__dlygate4sd3_1
Xhold158 data\[2\]\[51\] VGND VGND VPWR VPWR net309 sky130_fd_sc_hd__dlygate4sd3_1
Xhold103 data\[3\]\[16\] VGND VGND VPWR VPWR net254 sky130_fd_sc_hd__dlygate4sd3_1
Xhold114 data\[2\]\[3\] VGND VGND VPWR VPWR net265 sky130_fd_sc_hd__dlygate4sd3_1
X_1587_ net268 _0828_ _0623_ VGND VGND VPWR VPWR _0628_ sky130_fd_sc_hd__mux2_1
XFILLER_0_13_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold136 data\[2\]\[63\] VGND VGND VPWR VPWR net287 sky130_fd_sc_hd__dlygate4sd3_1
Xhold147 data\[3\]\[8\] VGND VGND VPWR VPWR net298 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_56_506 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2208_ clknet_leaf_29_clk _0348_ VGND VGND VPWR VPWR data\[1\]\[60\] sky130_fd_sc_hd__dfxtp_1
X_2139_ clknet_leaf_30_clk _0279_ VGND VGND VPWR VPWR data\[3\]\[63\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_64_561 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_63_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_49_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1510_ net494 _0379_ _0586_ VGND VGND VPWR VPWR _0587_ sky130_fd_sc_hd__mux2_1
XFILLER_0_4_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1441_ _0550_ VGND VGND VPWR VPWR _0161_ sky130_fd_sc_hd__clkbuf_1
X_1372_ _0514_ VGND VGND VPWR VPWR _0128_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_45_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_60_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1708_ _0772_ _0777_ _0771_ VGND VGND VPWR VPWR _0691_ sky130_fd_sc_hd__nor3b_2
XFILLER_0_26_382 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1639_ net299 _0913_ _0645_ VGND VGND VPWR VPWR _0655_ sky130_fd_sc_hd__mux2_1
XFILLER_0_36_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_36_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_36_102 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_51_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_27_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_0941_ _0781_ VGND VGND VPWR VPWR _0000_ sky130_fd_sc_hd__clkbuf_1
X_1990_ clknet_leaf_1_clk _0130_ VGND VGND VPWR VPWR data\[0\]\[58\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_2_235 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1355_ _0505_ VGND VGND VPWR VPWR _0120_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_2_279 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1424_ _0541_ VGND VGND VPWR VPWR _0153_ sky130_fd_sc_hd__clkbuf_1
X_1286_ _0469_ VGND VGND VPWR VPWR _0087_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_33_116 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_374 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_29_325 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_37_380 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_64_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_12_214 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_32_171 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1071_ _0774_ VGND VGND VPWR VPWR _0882_ sky130_fd_sc_hd__buf_4
X_1140_ net1 VGND VGND VPWR VPWR _0365_ sky130_fd_sc_hd__buf_4
XFILLER_0_1_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_62_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1973_ clknet_leaf_9_clk _0113_ VGND VGND VPWR VPWR data\[0\]\[41\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_30_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xhold29 data\[3\]\[43\] VGND VGND VPWR VPWR net180 sky130_fd_sc_hd__dlygate4sd3_1
X_1338_ net206 _0917_ _0496_ VGND VGND VPWR VPWR _0497_ sky130_fd_sc_hd__mux2_1
XFILLER_0_39_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xhold18 data\[3\]\[1\] VGND VGND VPWR VPWR net169 sky130_fd_sc_hd__dlygate4sd3_1
X_1407_ net466 _0782_ _0531_ VGND VGND VPWR VPWR _0533_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_26_306 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1269_ _0460_ VGND VGND VPWR VPWR _0079_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_34_361 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_14_160 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_32_16 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_52_299 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_40_397 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_20_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2172_ clknet_leaf_16_clk _0312_ VGND VGND VPWR VPWR data\[1\]\[24\] sky130_fd_sc_hd__dfxtp_1
X_1054_ net22 _0868_ _0848_ VGND VGND VPWR VPWR _0869_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_48_453 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1123_ _0922_ VGND VGND VPWR VPWR _0041_ sky130_fd_sc_hd__clkbuf_1
X_1887_ clknet_leaf_14_clk _0027_ VGND VGND VPWR VPWR data\[2\]\[27\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_43_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1956_ clknet_leaf_16_clk _0096_ VGND VGND VPWR VPWR data\[0\]\[24\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_31_342 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_7_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_11_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_11_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_2_70 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_54_489 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_34_288 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_45_434 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_43_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1810_ net349 _0374_ _0736_ VGND VGND VPWR VPWR _0745_ sky130_fd_sc_hd__mux2_1
X_1741_ net352 _0831_ _0703_ VGND VGND VPWR VPWR _0709_ sky130_fd_sc_hd__mux2_1
Xhold318 net116 VGND VGND VPWR VPWR net469 sky130_fd_sc_hd__dlygate4sd3_1
Xhold329 net119 VGND VGND VPWR VPWR net480 sky130_fd_sc_hd__dlygate4sd3_1
X_1672_ _0672_ VGND VGND VPWR VPWR _0270_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_7_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_0_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_7_48 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xhold307 net136 VGND VGND VPWR VPWR net458 sky130_fd_sc_hd__dlygate4sd3_1
X_1106_ data\[0\]\[38\] data\[1\]\[38\] data\[2\]\[38\] data\[3\]\[38\] _0901_ _0908_
+ VGND VGND VPWR VPWR _0909_ sky130_fd_sc_hd__mux4_1
X_2155_ clknet_leaf_22_clk _0295_ VGND VGND VPWR VPWR data\[1\]\[7\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_23_6 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_63_317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_48_358 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1037_ net18 _0855_ _0848_ VGND VGND VPWR VPWR _0856_ sky130_fd_sc_hd__mux2_1
X_2086_ clknet_leaf_24_clk _0226_ VGND VGND VPWR VPWR data\[3\]\[10\] sky130_fd_sc_hd__dfxtp_1
X_1939_ clknet_leaf_22_clk _0079_ VGND VGND VPWR VPWR data\[0\]\[7\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_16_288 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_42_415 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_11_Right_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_13_18 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_20_Right_20 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_22_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_22_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_22_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_60_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold104 data\[2\]\[21\] VGND VGND VPWR VPWR net255 sky130_fd_sc_hd__dlygate4sd3_1
Xhold126 data\[0\]\[54\] VGND VGND VPWR VPWR net277 sky130_fd_sc_hd__dlygate4sd3_1
Xhold115 data\[1\]\[50\] VGND VGND VPWR VPWR net266 sky130_fd_sc_hd__dlygate4sd3_1
X_1724_ net243 _0803_ _0692_ VGND VGND VPWR VPWR _0700_ sky130_fd_sc_hd__mux2_1
X_1655_ _0663_ VGND VGND VPWR VPWR _0262_ sky130_fd_sc_hd__clkbuf_1
Xhold148 data\[3\]\[39\] VGND VGND VPWR VPWR net299 sky130_fd_sc_hd__dlygate4sd3_1
Xhold137 data\[3\]\[0\] VGND VGND VPWR VPWR net288 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_0_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xhold159 data\[3\]\[66\] VGND VGND VPWR VPWR net310 sky130_fd_sc_hd__dlygate4sd3_1
X_1586_ _0627_ VGND VGND VPWR VPWR _0229_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_64_562 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_48_100 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2207_ clknet_leaf_2_clk _0347_ VGND VGND VPWR VPWR data\[1\]\[59\] sky130_fd_sc_hd__dfxtp_1
X_2138_ clknet_leaf_28_clk _0278_ VGND VGND VPWR VPWR data\[3\]\[62\] sky130_fd_sc_hd__dfxtp_1
X_2069_ clknet_leaf_1_clk _0209_ VGND VGND VPWR VPWR net138 sky130_fd_sc_hd__dfxtp_1
XFILLER_0_63_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_63_125 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_48_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_4_162 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_42_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1371_ net453 _0401_ _0507_ VGND VGND VPWR VPWR _0514_ sky130_fd_sc_hd__mux2_1
XFILLER_0_4_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1440_ net492 _0837_ _0542_ VGND VGND VPWR VPWR _0550_ sky130_fd_sc_hd__mux2_1
XFILLER_0_14_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_18_253 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_18_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_18_328 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_60_128 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_41_364 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1638_ _0654_ VGND VGND VPWR VPWR _0254_ sky130_fd_sc_hd__clkbuf_1
X_1707_ _0690_ VGND VGND VPWR VPWR _0287_ sky130_fd_sc_hd__clkbuf_1
X_1569_ _0618_ VGND VGND VPWR VPWR _0221_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_1_143 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_32_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_35_16 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_51_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0940_ net429 _0776_ _0780_ VGND VGND VPWR VPWR _0781_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_15_234 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_42_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_2_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1354_ net196 _0374_ _0496_ VGND VGND VPWR VPWR _0505_ sky130_fd_sc_hd__mux2_1
X_1285_ net449 _0831_ _0463_ VGND VGND VPWR VPWR _0469_ sky130_fd_sc_hd__mux2_1
X_1423_ net490 _0810_ _0531_ VGND VGND VPWR VPWR _0541_ sky130_fd_sc_hd__mux2_1
XFILLER_0_41_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_29_326 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_64_231 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_37_381 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_12_215 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_20_270 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_24_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1070_ data\[0\]\[30\] data\[1\]\[30\] data\[2\]\[30\] data\[3\]\[30\] _0867_ _0874_
+ VGND VGND VPWR VPWR _0881_ sky130_fd_sc_hd__mux4_1
XFILLER_0_1_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1972_ clknet_leaf_7_clk _0112_ VGND VGND VPWR VPWR data\[0\]\[40\] sky130_fd_sc_hd__dfxtp_1
XPHY_EDGE_ROW_49_Right_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_11_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_58_Right_58 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1337_ _0451_ VGND VGND VPWR VPWR _0496_ sky130_fd_sc_hd__buf_4
X_1268_ net168 _0803_ _0452_ VGND VGND VPWR VPWR _0460_ sky130_fd_sc_hd__mux2_1
X_1406_ _0532_ VGND VGND VPWR VPWR _0144_ sky130_fd_sc_hd__clkbuf_1
Xhold19 data\[1\]\[67\] VGND VGND VPWR VPWR net170 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_38_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_34_362 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_26_307 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1199_ net58 _0410_ _0380_ VGND VGND VPWR VPWR _0411_ sky130_fd_sc_hd__mux2_1
XFILLER_0_61_267 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_46_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_14_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_37_297 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_4_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_52_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_40_398 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1122_ net191 _0921_ _0918_ VGND VGND VPWR VPWR _0922_ sky130_fd_sc_hd__mux2_1
X_2171_ clknet_leaf_16_clk _0311_ VGND VGND VPWR VPWR data\[1\]\[23\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_20_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1053_ data\[0\]\[26\] data\[1\]\[26\] data\[2\]\[26\] data\[3\]\[26\] _0867_ _0840_
+ VGND VGND VPWR VPWR _0868_ sky130_fd_sc_hd__mux4_1
XTAP_TAPCELL_ROW_48_454 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1886_ clknet_leaf_13_clk _0026_ VGND VGND VPWR VPWR data\[2\]\[26\] sky130_fd_sc_hd__dfxtp_1
X_1955_ clknet_leaf_16_clk _0095_ VGND VGND VPWR VPWR data\[0\]\[23\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_31_343 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_7_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_51_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_19_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_34_256 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_57_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xhold308 net113 VGND VGND VPWR VPWR net459 sky130_fd_sc_hd__dlygate4sd3_1
X_1671_ net305 _0394_ _0667_ VGND VGND VPWR VPWR _0672_ sky130_fd_sc_hd__mux2_1
XFILLER_0_25_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_7_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1740_ _0708_ VGND VGND VPWR VPWR _0302_ sky130_fd_sc_hd__clkbuf_1
Xhold319 net129 VGND VGND VPWR VPWR net470 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_0_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1105_ _0805_ VGND VGND VPWR VPWR _0908_ sky130_fd_sc_hd__clkbuf_4
X_2154_ clknet_leaf_23_clk _0294_ VGND VGND VPWR VPWR data\[1\]\[6\] sky130_fd_sc_hd__dfxtp_1
X_2085_ clknet_leaf_24_clk _0225_ VGND VGND VPWR VPWR data\[3\]\[9\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_63_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_48_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1036_ data\[0\]\[22\] data\[1\]\[22\] data\[2\]\[22\] data\[3\]\[22\] _0833_ _0840_
+ VGND VGND VPWR VPWR _0855_ sky130_fd_sc_hd__mux4_1
XFILLER_0_33_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1938_ clknet_leaf_22_clk _0078_ VGND VGND VPWR VPWR data\[0\]\[6\] sky130_fd_sc_hd__dfxtp_1
X_1869_ clknet_leaf_24_clk _0009_ VGND VGND VPWR VPWR data\[2\]\[9\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_39_326 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_54_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_38_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_7_182 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_57_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1654_ net285 _0367_ _0656_ VGND VGND VPWR VPWR _0663_ sky130_fd_sc_hd__mux2_1
Xhold127 data\[1\]\[30\] VGND VGND VPWR VPWR net278 sky130_fd_sc_hd__dlygate4sd3_1
Xhold116 data\[3\]\[55\] VGND VGND VPWR VPWR net267 sky130_fd_sc_hd__dlygate4sd3_1
Xhold138 data\[1\]\[21\] VGND VGND VPWR VPWR net289 sky130_fd_sc_hd__dlygate4sd3_1
X_1723_ _0699_ VGND VGND VPWR VPWR _0294_ sky130_fd_sc_hd__clkbuf_1
Xhold105 data\[0\]\[14\] VGND VGND VPWR VPWR net256 sky130_fd_sc_hd__dlygate4sd3_1
Xhold149 data\[2\]\[8\] VGND VGND VPWR VPWR net300 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_0_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1585_ net324 _0825_ _0623_ VGND VGND VPWR VPWR _0627_ sky130_fd_sc_hd__mux2_1
X_2206_ clknet_leaf_1_clk _0346_ VGND VGND VPWR VPWR data\[1\]\[58\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_64_563 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_64_552 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_48_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_44_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1019_ net13 _0841_ _0814_ VGND VGND VPWR VPWR _0842_ sky130_fd_sc_hd__mux2_1
X_2068_ clknet_leaf_29_clk _0208_ VGND VGND VPWR VPWR net137 sky130_fd_sc_hd__dfxtp_1
X_2137_ clknet_leaf_28_clk _0277_ VGND VGND VPWR VPWR data\[3\]\[61\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_63_137 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_36_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_8_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_4_163 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_39_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_40_17 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_62_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_50_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_49_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1370_ _0513_ VGND VGND VPWR VPWR _0127_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_18_254 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_61_533 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_5_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1637_ net312 _0910_ _0645_ VGND VGND VPWR VPWR _0654_ sky130_fd_sc_hd__mux2_1
X_1706_ net224 _0449_ _0611_ VGND VGND VPWR VPWR _0690_ sky130_fd_sc_hd__mux2_1
X_1499_ net469 _0362_ _0575_ VGND VGND VPWR VPWR _0581_ sky130_fd_sc_hd__mux2_1
X_1568_ net187 _0795_ _0612_ VGND VGND VPWR VPWR _0618_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_1_144 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_51_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_32_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_9_200 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_3_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_51_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_41_Left_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_15_235 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_23_290 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1422_ _0540_ VGND VGND VPWR VPWR _0152_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_23_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_50_Left_115 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1353_ _0504_ VGND VGND VPWR VPWR _0119_ sky130_fd_sc_hd__clkbuf_1
X_1284_ _0468_ VGND VGND VPWR VPWR _0086_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_41_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_0999_ _0826_ VGND VGND VPWR VPWR _0013_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_1_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_1_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_29_327 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_37_382 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_12_216 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_17_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_20_271 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_46_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_62_59 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_62_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1971_ clknet_leaf_9_clk _0111_ VGND VGND VPWR VPWR data\[0\]\[39\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_15_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1405_ net456 _0773_ _0531_ VGND VGND VPWR VPWR _0532_ sky130_fd_sc_hd__mux2_1
XFILLER_0_11_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_11_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1336_ _0495_ VGND VGND VPWR VPWR _0111_ sky130_fd_sc_hd__clkbuf_1
Xinput1 address[0] VGND VGND VPWR VPWR net1 sky130_fd_sc_hd__clkbuf_2
XTAP_TAPCELL_ROW_26_308 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1198_ data\[0\]\[59\] data\[1\]\[59\] data\[2\]\[59\] data\[3\]\[59\] _0399_ _0406_
+ VGND VGND VPWR VPWR _0410_ sky130_fd_sc_hd__mux4_1
X_1267_ _0459_ VGND VGND VPWR VPWR _0078_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_46_210 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_34_363 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_61_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_6_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_14_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_32_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_40_399 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_37_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_57_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_20_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1121_ net39 _0920_ _0916_ VGND VGND VPWR VPWR _0921_ sky130_fd_sc_hd__mux2_1
X_2170_ clknet_leaf_14_clk _0310_ VGND VGND VPWR VPWR data\[1\]\[22\] sky130_fd_sc_hd__dfxtp_1
X_1052_ _0797_ VGND VGND VPWR VPWR _0867_ sky130_fd_sc_hd__buf_4
X_1954_ clknet_leaf_14_clk _0094_ VGND VGND VPWR VPWR data\[0\]\[22\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_28_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_7_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_43_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_43_202 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1885_ clknet_leaf_16_clk _0025_ VGND VGND VPWR VPWR data\[2\]\[25\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_11_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1319_ net198 _0887_ _0485_ VGND VGND VPWR VPWR _0487_ sky130_fd_sc_hd__mux2_1
XFILLER_0_19_210 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_42_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_40_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1670_ _0671_ VGND VGND VPWR VPWR _0269_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_25_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold309 net138 VGND VGND VPWR VPWR net460 sky130_fd_sc_hd__dlygate4sd3_1
X_1104_ _0907_ VGND VGND VPWR VPWR _0037_ sky130_fd_sc_hd__clkbuf_1
X_1035_ _0854_ VGND VGND VPWR VPWR _0021_ sky130_fd_sc_hd__clkbuf_1
X_2153_ clknet_leaf_26_clk _0293_ VGND VGND VPWR VPWR data\[1\]\[5\] sky130_fd_sc_hd__dfxtp_1
X_2084_ clknet_leaf_23_clk _0224_ VGND VGND VPWR VPWR data\[3\]\[8\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_33_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1937_ clknet_leaf_23_clk _0077_ VGND VGND VPWR VPWR data\[0\]\[5\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_16_224 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1799_ _0739_ VGND VGND VPWR VPWR _0330_ sky130_fd_sc_hd__clkbuf_1
Xinput70 wdata[6] VGND VGND VPWR VPWR net70 sky130_fd_sc_hd__clkbuf_1
X_1868_ clknet_leaf_23_clk _0008_ VGND VGND VPWR VPWR data\[2\]\[8\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_62_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_50_461 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_22_227 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_7_183 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_45_319 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_38_382 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_38_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold128 data\[1\]\[35\] VGND VGND VPWR VPWR net279 sky130_fd_sc_hd__dlygate4sd3_1
Xhold139 data\[2\]\[31\] VGND VGND VPWR VPWR net290 sky130_fd_sc_hd__dlygate4sd3_1
X_1653_ _0662_ VGND VGND VPWR VPWR _0261_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_53_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold106 data\[0\]\[6\] VGND VGND VPWR VPWR net257 sky130_fd_sc_hd__dlygate4sd3_1
X_1722_ net314 _0800_ _0692_ VGND VGND VPWR VPWR _0699_ sky130_fd_sc_hd__mux2_1
XPHY_EDGE_ROW_9_Right_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold117 data\[3\]\[14\] VGND VGND VPWR VPWR net268 sky130_fd_sc_hd__dlygate4sd3_1
X_1584_ _0626_ VGND VGND VPWR VPWR _0228_ sky130_fd_sc_hd__clkbuf_1
X_2205_ clknet_leaf_0_clk _0345_ VGND VGND VPWR VPWR data\[1\]\[57\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_64_564 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_64_553 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_48_168 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1018_ data\[0\]\[18\] data\[1\]\[18\] data\[2\]\[18\] data\[3\]\[18\] _0833_ _0840_
+ VGND VGND VPWR VPWR _0841_ sky130_fd_sc_hd__mux4_1
X_2136_ clknet_leaf_29_clk _0276_ VGND VGND VPWR VPWR data\[3\]\[60\] sky130_fd_sc_hd__dfxtp_1
X_2067_ clknet_leaf_30_clk _0207_ VGND VGND VPWR VPWR net136 sky130_fd_sc_hd__dfxtp_1
XFILLER_0_63_149 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_63_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_4_164 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_39_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_40_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_35_374 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_61_534 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_18_255 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_41_322 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1705_ _0689_ VGND VGND VPWR VPWR _0286_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_5_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1636_ _0653_ VGND VGND VPWR VPWR _0253_ sky130_fd_sc_hd__clkbuf_1
X_1567_ _0617_ VGND VGND VPWR VPWR _0220_ sky130_fd_sc_hd__clkbuf_1
X_1498_ _0580_ VGND VGND VPWR VPWR _0188_ sky130_fd_sc_hd__clkbuf_1
X_2119_ clknet_leaf_6_clk _0259_ VGND VGND VPWR VPWR data\[3\]\[43\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_1_145 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_44_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_42_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_27_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_27_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_15_236 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_23_311 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_23_291 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_50_152 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1421_ net475 _0807_ _0531_ VGND VGND VPWR VPWR _0540_ sky130_fd_sc_hd__mux2_1
XFILLER_0_23_366 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1352_ net323 _0370_ _0496_ VGND VGND VPWR VPWR _0504_ sky130_fd_sc_hd__mux2_1
X_1283_ net256 _0828_ _0463_ VGND VGND VPWR VPWR _0468_ sky130_fd_sc_hd__mux2_1
XFILLER_0_25_84 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_0998_ net394 _0825_ _0816_ VGND VGND VPWR VPWR _0826_ sky130_fd_sc_hd__mux2_1
X_1619_ _0644_ VGND VGND VPWR VPWR _0245_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_5_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_1_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_29_328 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_64_299 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_12_217 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_17_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_20_358 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_20_272 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_62_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_62_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1970_ clknet_leaf_10_clk _0110_ VGND VGND VPWR VPWR data\[0\]\[38\] sky130_fd_sc_hd__dfxtp_1
XPHY_EDGE_ROW_23_Left_88 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_55_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1335_ net451 _0913_ _0485_ VGND VGND VPWR VPWR _0495_ sky130_fd_sc_hd__mux2_1
X_1404_ _0778_ VGND VGND VPWR VPWR _0531_ sky130_fd_sc_hd__buf_4
XTAP_TAPCELL_ROW_26_309 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1266_ net257 _0800_ _0452_ VGND VGND VPWR VPWR _0459_ sky130_fd_sc_hd__mux2_1
Xinput2 address[1] VGND VGND VPWR VPWR net2 sky130_fd_sc_hd__clkbuf_2
X_1197_ _0409_ VGND VGND VPWR VPWR _0058_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_61_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_52_71 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_37_255 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_20_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_20_155 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1120_ data\[0\]\[41\] data\[1\]\[41\] data\[2\]\[41\] data\[3\]\[41\] _0901_ _0908_
+ VGND VGND VPWR VPWR _0920_ sky130_fd_sc_hd__mux4_1
X_1051_ _0866_ VGND VGND VPWR VPWR _0025_ sky130_fd_sc_hd__clkbuf_1
X_1884_ clknet_leaf_16_clk _0024_ VGND VGND VPWR VPWR data\[2\]\[24\] sky130_fd_sc_hd__dfxtp_1
X_1953_ clknet_leaf_19_clk _0093_ VGND VGND VPWR VPWR data\[0\]\[21\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_22_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_22_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_11_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1318_ _0486_ VGND VGND VPWR VPWR _0102_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_37_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_63_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1249_ net72 _0448_ _0774_ VGND VGND VPWR VPWR _0449_ sky130_fd_sc_hd__mux2_1
XFILLER_0_34_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_19_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_53_481 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_25_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2152_ clknet_leaf_25_clk _0292_ VGND VGND VPWR VPWR data\[1\]\[4\] sky130_fd_sc_hd__dfxtp_1
X_1103_ net311 _0906_ _0884_ VGND VGND VPWR VPWR _0907_ sky130_fd_sc_hd__mux2_1
X_1034_ net255 _0853_ _0850_ VGND VGND VPWR VPWR _0854_ sky130_fd_sc_hd__mux2_1
X_2083_ clknet_leaf_23_clk _0223_ VGND VGND VPWR VPWR data\[3\]\[7\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_33_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_26_Left_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1867_ clknet_leaf_23_clk _0007_ VGND VGND VPWR VPWR data\[2\]\[7\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_16_236 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_16_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1936_ clknet_leaf_25_clk _0076_ VGND VGND VPWR VPWR data\[0\]\[4\] sky130_fd_sc_hd__dfxtp_1
X_1798_ net214 _0924_ _0736_ VGND VGND VPWR VPWR _0739_ sky130_fd_sc_hd__mux2_1
Xinput71 wdata[70] VGND VGND VPWR VPWR net71 sky130_fd_sc_hd__buf_1
XPHY_EDGE_ROW_10_Left_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xinput60 wdata[60] VGND VGND VPWR VPWR net60 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_47_350 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_50_462 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_22_239 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_38_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_7_184 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_57_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1721_ _0698_ VGND VGND VPWR VPWR _0293_ sky130_fd_sc_hd__clkbuf_1
X_1652_ net165 _0363_ _0656_ VGND VGND VPWR VPWR _0662_ sky130_fd_sc_hd__mux2_1
XFILLER_0_0_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_0_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold118 data\[2\]\[60\] VGND VGND VPWR VPWR net269 sky130_fd_sc_hd__dlygate4sd3_1
X_1583_ net297 _0822_ _0623_ VGND VGND VPWR VPWR _0626_ sky130_fd_sc_hd__mux2_1
Xhold107 data\[1\]\[9\] VGND VGND VPWR VPWR net258 sky130_fd_sc_hd__dlygate4sd3_1
Xhold129 data\[2\]\[4\] VGND VGND VPWR VPWR net280 sky130_fd_sc_hd__dlygate4sd3_1
X_2204_ clknet_leaf_0_clk _0344_ VGND VGND VPWR VPWR data\[1\]\[56\] sky130_fd_sc_hd__dfxtp_1
X_2135_ clknet_leaf_1_clk _0275_ VGND VGND VPWR VPWR data\[3\]\[59\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_21_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_64_554 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1017_ _0805_ VGND VGND VPWR VPWR _0840_ sky130_fd_sc_hd__clkbuf_4
X_2066_ clknet_leaf_27_clk _0206_ VGND VGND VPWR VPWR net135 sky130_fd_sc_hd__dfxtp_1
XFILLER_0_60_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_56_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_44_342 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1919_ clknet_leaf_1_clk _0059_ VGND VGND VPWR VPWR data\[2\]\[59\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_8_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_12_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_4_165 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_39_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_61_535 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_18_256 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_18_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_38_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1704_ net263 _0446_ _0611_ VGND VGND VPWR VPWR _0689_ sky130_fd_sc_hd__mux2_1
XFILLER_0_30_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_5_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1635_ net183 _0906_ _0645_ VGND VGND VPWR VPWR _0653_ sky130_fd_sc_hd__mux2_1
X_1497_ net382 _0929_ _0575_ VGND VGND VPWR VPWR _0580_ sky130_fd_sc_hd__mux2_1
XFILLER_0_39_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_39_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1566_ net433 _0792_ _0612_ VGND VGND VPWR VPWR _0617_ sky130_fd_sc_hd__mux2_1
X_2118_ clknet_leaf_7_clk _0258_ VGND VGND VPWR VPWR data\[3\]\[42\] sky130_fd_sc_hd__dfxtp_1
X_2049_ clknet_leaf_7_clk _0189_ VGND VGND VPWR VPWR net116 sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_1_146 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_44_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_4_280 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_15_237 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_50_120 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1351_ _0503_ VGND VGND VPWR VPWR _0118_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_50_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_50_164 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1420_ _0539_ VGND VGND VPWR VPWR _0151_ sky130_fd_sc_hd__clkbuf_1
X_1282_ _0467_ VGND VGND VPWR VPWR _0085_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_58_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_58_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_41_84 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_41_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_18_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1618_ net328 _0879_ _0634_ VGND VGND VPWR VPWR _0644_ sky130_fd_sc_hd__mux2_1
XFILLER_0_14_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_0997_ net8 _0824_ _0814_ VGND VGND VPWR VPWR _0825_ sky130_fd_sc_hd__mux2_1
X_1549_ net485 _0442_ _0597_ VGND VGND VPWR VPWR _0607_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_29_329 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_64_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_64_267 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_64_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_12_218 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xhold290 net83 VGND VGND VPWR VPWR net441 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_46_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_55_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_11_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_23_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1334_ _0494_ VGND VGND VPWR VPWR _0110_ sky130_fd_sc_hd__clkbuf_1
X_1403_ _0530_ VGND VGND VPWR VPWR _0143_ sky130_fd_sc_hd__clkbuf_1
X_1265_ _0458_ VGND VGND VPWR VPWR _0077_ sky130_fd_sc_hd__clkbuf_1
XPHY_EDGE_ROW_18_Right_18 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xinput3 en_n VGND VGND VPWR VPWR net3 sky130_fd_sc_hd__buf_1
XPHY_EDGE_ROW_27_Right_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1196_ net393 _0408_ _0382_ VGND VGND VPWR VPWR _0409_ sky130_fd_sc_hd__mux2_1
XFILLER_0_52_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_46_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_46_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_36_Right_36 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_45_Right_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_54_Right_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_52_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_63_Right_63 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_38_Left_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1050_ net406 _0865_ _0850_ VGND VGND VPWR VPWR _0866_ sky130_fd_sc_hd__mux2_1
X_1883_ clknet_leaf_16_clk _0023_ VGND VGND VPWR VPWR data\[2\]\[23\] sky130_fd_sc_hd__dfxtp_1
X_1952_ clknet_leaf_15_clk _0092_ VGND VGND VPWR VPWR data\[0\]\[20\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_28_267 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_28_234 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_47_Left_112 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_11_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_11_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_47_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1317_ net212 _0883_ _0485_ VGND VGND VPWR VPWR _0486_ sky130_fd_sc_hd__mux2_1
X_1248_ data\[0\]\[71\] data\[1\]\[71\] data\[2\]\[71\] data\[3\]\[71\] _0797_ _0805_
+ VGND VGND VPWR VPWR _0448_ sky130_fd_sc_hd__mux4_1
XFILLER_0_63_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_56_Left_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1179_ _0395_ VGND VGND VPWR VPWR _0054_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_2_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_19_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_19_234 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_53_482 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_0_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1102_ net34 _0905_ _0882_ VGND VGND VPWR VPWR _0906_ sky130_fd_sc_hd__mux2_1
X_2151_ clknet_leaf_25_clk _0291_ VGND VGND VPWR VPWR data\[1\]\[3\] sky130_fd_sc_hd__dfxtp_1
X_2082_ clknet_leaf_23_clk _0222_ VGND VGND VPWR VPWR data\[3\]\[6\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_48_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1033_ net17 _0852_ _0848_ VGND VGND VPWR VPWR _0853_ sky130_fd_sc_hd__mux2_1
XFILLER_0_16_9 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_56_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1797_ _0738_ VGND VGND VPWR VPWR _0329_ sky130_fd_sc_hd__clkbuf_1
Xinput50 wdata[51] VGND VGND VPWR VPWR net50 sky130_fd_sc_hd__buf_1
Xinput72 wdata[71] VGND VGND VPWR VPWR net72 sky130_fd_sc_hd__buf_1
X_1935_ clknet_leaf_17_clk _0075_ VGND VGND VPWR VPWR data\[0\]\[3\] sky130_fd_sc_hd__dfxtp_1
Xinput61 wdata[61] VGND VGND VPWR VPWR net61 sky130_fd_sc_hd__clkbuf_1
X_1866_ clknet_leaf_23_clk _0006_ VGND VGND VPWR VPWR data\[2\]\[6\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_62_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_50_463 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_0_Right_0 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_62_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_30_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_54_18 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_7_185 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1651_ _0661_ VGND VGND VPWR VPWR _0260_ sky130_fd_sc_hd__clkbuf_1
Xhold108 data\[2\]\[64\] VGND VGND VPWR VPWR net259 sky130_fd_sc_hd__dlygate4sd3_1
X_1720_ net296 _0795_ _0692_ VGND VGND VPWR VPWR _0698_ sky130_fd_sc_hd__mux2_1
Xhold119 data\[1\]\[26\] VGND VGND VPWR VPWR net270 sky130_fd_sc_hd__dlygate4sd3_1
X_1582_ _0625_ VGND VGND VPWR VPWR _0227_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_21_262 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2203_ clknet_leaf_4_clk _0343_ VGND VGND VPWR VPWR data\[1\]\[55\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_28_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2134_ clknet_leaf_0_clk _0274_ VGND VGND VPWR VPWR data\[3\]\[58\] sky130_fd_sc_hd__dfxtp_1
X_2065_ clknet_leaf_28_clk _0205_ VGND VGND VPWR VPWR net134 sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_64_555 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_44_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1016_ _0839_ VGND VGND VPWR VPWR _0017_ sky130_fd_sc_hd__clkbuf_1
X_1849_ _0765_ VGND VGND VPWR VPWR _0354_ sky130_fd_sc_hd__clkbuf_1
X_1918_ clknet_leaf_0_clk _0058_ VGND VGND VPWR VPWR data\[2\]\[58\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_4_166 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_leaf_20_clk clknet_2_2__leaf_clk VGND VGND VPWR VPWR clknet_leaf_20_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_0_50_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_61_536 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_18_257 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1634_ _0652_ VGND VGND VPWR VPWR _0252_ sky130_fd_sc_hd__clkbuf_1
Xclkbuf_leaf_11_clk clknet_2_3__leaf_clk VGND VGND VPWR VPWR clknet_leaf_11_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_0_41_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_30_42 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_26_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_26_343 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1703_ _0688_ VGND VGND VPWR VPWR _0285_ sky130_fd_sc_hd__clkbuf_1
X_1496_ _0579_ VGND VGND VPWR VPWR _0187_ sky130_fd_sc_hd__clkbuf_1
X_1565_ _0616_ VGND VGND VPWR VPWR _0219_ sky130_fd_sc_hd__clkbuf_1
X_2048_ clknet_leaf_6_clk _0188_ VGND VGND VPWR VPWR net115 sky130_fd_sc_hd__dfxtp_1
X_2117_ clknet_leaf_9_clk _0257_ VGND VGND VPWR VPWR data\[3\]\[41\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_1_147 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_12_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_376 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_4_292 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_27_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_15_238 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_50_176 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_50_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_35_140 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_2_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1350_ net389 _0367_ _0496_ VGND VGND VPWR VPWR _0503_ sky130_fd_sc_hd__mux2_1
X_1281_ net436 _0825_ _0463_ VGND VGND VPWR VPWR _0467_ sky130_fd_sc_hd__mux2_1
XFILLER_0_58_232 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_leaf_0_clk clknet_2_0__leaf_clk VGND VGND VPWR VPWR clknet_leaf_0_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_0_41_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_0996_ data\[0\]\[13\] data\[1\]\[13\] data\[2\]\[13\] data\[3\]\[13\] _0798_ _0806_
+ VGND VGND VPWR VPWR _0824_ sky130_fd_sc_hd__mux4_1
X_1617_ _0643_ VGND VGND VPWR VPWR _0244_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_14_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_14_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1479_ _0570_ VGND VGND VPWR VPWR _0179_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_5_96 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1548_ _0606_ VGND VGND VPWR VPWR _0212_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_49_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_49_210 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_351 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_9_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_12_219 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xhold280 data\[2\]\[36\] VGND VGND VPWR VPWR net431 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_1_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold291 data\[0\]\[8\] VGND VGND VPWR VPWR net442 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_20_338 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_62_29 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1402_ net329 _0449_ net151 VGND VGND VPWR VPWR _0530_ sky130_fd_sc_hd__mux2_1
XFILLER_0_46_9 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1333_ net343 _0910_ _0485_ VGND VGND VPWR VPWR _0494_ sky130_fd_sc_hd__mux2_1
Xinput4 wdata[0] VGND VGND VPWR VPWR net4 sky130_fd_sc_hd__clkbuf_1
X_1264_ net353 _0795_ _0452_ VGND VGND VPWR VPWR _0458_ sky130_fd_sc_hd__mux2_1
XFILLER_0_46_224 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkbuf_2_1__f_clk clknet_0_clk VGND VGND VPWR VPWR clknet_2_1__leaf_clk sky130_fd_sc_hd__clkbuf_16
X_1195_ net57 _0407_ _0380_ VGND VGND VPWR VPWR _0408_ sky130_fd_sc_hd__mux2_1
XFILLER_0_61_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_6_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_0979_ net75 _0810_ _0775_ VGND VGND VPWR VPWR _0811_ sky130_fd_sc_hd__mux2_1
XFILLER_0_37_268 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_37_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_25_300 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_52_238 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1882_ clknet_leaf_14_clk _0022_ VGND VGND VPWR VPWR data\[2\]\[22\] sky130_fd_sc_hd__dfxtp_1
X_1951_ clknet_leaf_19_clk _0091_ VGND VGND VPWR VPWR data\[0\]\[19\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_3_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_22_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_22_76 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_44_6 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_11_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1316_ net151 VGND VGND VPWR VPWR _0485_ sky130_fd_sc_hd__buf_4
X_1178_ net333 _0394_ _0382_ VGND VGND VPWR VPWR _0395_ sky130_fd_sc_hd__mux2_1
X_1247_ _0447_ VGND VGND VPWR VPWR _0070_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_2_42 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_53_483 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_25_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_0_349 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1101_ data\[0\]\[37\] data\[1\]\[37\] data\[2\]\[37\] data\[3\]\[37\] _0901_ _0874_
+ VGND VGND VPWR VPWR _0905_ sky130_fd_sc_hd__mux4_1
X_1032_ data\[0\]\[21\] data\[1\]\[21\] data\[2\]\[21\] data\[3\]\[21\] _0833_ _0840_
+ VGND VGND VPWR VPWR _0852_ sky130_fd_sc_hd__mux4_1
X_2081_ clknet_leaf_26_clk _0221_ VGND VGND VPWR VPWR data\[3\]\[5\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_17_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2150_ clknet_leaf_25_clk _0290_ VGND VGND VPWR VPWR data\[1\]\[2\] sky130_fd_sc_hd__dfxtp_1
X_1934_ clknet_leaf_25_clk _0074_ VGND VGND VPWR VPWR data\[0\]\[2\] sky130_fd_sc_hd__dfxtp_1
Xinput40 wdata[42] VGND VGND VPWR VPWR net40 sky130_fd_sc_hd__clkbuf_1
X_1796_ net370 _0921_ _0736_ VGND VGND VPWR VPWR _0738_ sky130_fd_sc_hd__mux2_1
Xinput51 wdata[52] VGND VGND VPWR VPWR net51 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_3_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xinput73 wdata[7] VGND VGND VPWR VPWR net73 sky130_fd_sc_hd__clkbuf_1
Xinput62 wdata[62] VGND VGND VPWR VPWR net62 sky130_fd_sc_hd__clkbuf_1
X_1865_ clknet_leaf_26_clk _0005_ VGND VGND VPWR VPWR data\[2\]\[5\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_16_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_3_198 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_42_409 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_62_333 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_50_464 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_62_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_30_263 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_7_186 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1650_ net293 _0360_ _0656_ VGND VGND VPWR VPWR _0661_ sky130_fd_sc_hd__mux2_1
Xhold109 data\[3\]\[40\] VGND VGND VPWR VPWR net260 sky130_fd_sc_hd__dlygate4sd3_1
X_1581_ net154 _0819_ _0623_ VGND VGND VPWR VPWR _0625_ sky130_fd_sc_hd__mux2_1
X_2202_ clknet_leaf_4_clk _0342_ VGND VGND VPWR VPWR data\[1\]\[54\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_0_146 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_64_556 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_44_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2133_ clknet_leaf_0_clk _0273_ VGND VGND VPWR VPWR data\[3\]\[57\] sky130_fd_sc_hd__dfxtp_1
X_2064_ clknet_leaf_28_clk _0204_ VGND VGND VPWR VPWR net133 sky130_fd_sc_hd__dfxtp_1
XFILLER_0_14_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1015_ net226 _0838_ _0816_ VGND VGND VPWR VPWR _0839_ sky130_fd_sc_hd__mux2_1
XFILLER_0_60_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1917_ clknet_leaf_0_clk _0057_ VGND VGND VPWR VPWR data\[2\]\[57\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_8_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1779_ net215 _0893_ _0725_ VGND VGND VPWR VPWR _0729_ sky130_fd_sc_hd__mux2_1
X_1848_ net281 _0434_ _0758_ VGND VGND VPWR VPWR _0765_ sky130_fd_sc_hd__mux2_1
XFILLER_0_12_296 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_4_167 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_39_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_62_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_62_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_50_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_50_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_18_258 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_61_537 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1633_ net292 _0903_ _0645_ VGND VGND VPWR VPWR _0652_ sky130_fd_sc_hd__mux2_1
XFILLER_0_41_314 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1564_ net227 _0789_ _0612_ VGND VGND VPWR VPWR _0616_ sky130_fd_sc_hd__mux2_1
X_1702_ net331 _0443_ _0678_ VGND VGND VPWR VPWR _0688_ sky130_fd_sc_hd__mux2_1
X_1495_ net437 _0926_ _0575_ VGND VGND VPWR VPWR _0579_ sky130_fd_sc_hd__mux2_1
X_2047_ clknet_leaf_6_clk _0187_ VGND VGND VPWR VPWR net114 sky130_fd_sc_hd__dfxtp_1
X_2116_ clknet_leaf_5_clk _0256_ VGND VGND VPWR VPWR data\[3\]\[40\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_1_148 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_32_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_4_271 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_15_239 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1280_ _0466_ VGND VGND VPWR VPWR _0084_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_58_277 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_41_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_41_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_26_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_0995_ _0823_ VGND VGND VPWR VPWR _0012_ sky130_fd_sc_hd__clkbuf_1
X_1616_ net164 _0876_ _0634_ VGND VGND VPWR VPWR _0643_ sky130_fd_sc_hd__mux2_1
XFILLER_0_41_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1547_ net496 _0439_ _0597_ VGND VGND VPWR VPWR _0606_ sky130_fd_sc_hd__mux2_1
X_1478_ net414 _0898_ _0564_ VGND VGND VPWR VPWR _0570_ sky130_fd_sc_hd__mux2_1
XFILLER_0_49_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_17_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_17_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_20_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold270 net95 VGND VGND VPWR VPWR net421 sky130_fd_sc_hd__dlygate4sd3_1
Xhold292 data\[2\]\[27\] VGND VGND VPWR VPWR net443 sky130_fd_sc_hd__dlygate4sd3_1
Xhold281 data\[3\]\[27\] VGND VGND VPWR VPWR net432 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_28_320 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_55_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_55_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_23_100 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1401_ _0529_ VGND VGND VPWR VPWR _0142_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_23_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1332_ _0493_ VGND VGND VPWR VPWR _0109_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_36_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1194_ data\[0\]\[58\] data\[1\]\[58\] data\[2\]\[58\] data\[3\]\[58\] _0399_ _0406_
+ VGND VGND VPWR VPWR _0407_ sky130_fd_sc_hd__mux4_1
Xinput5 wdata[10] VGND VGND VPWR VPWR net5 sky130_fd_sc_hd__clkbuf_1
X_1263_ _0457_ VGND VGND VPWR VPWR _0076_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_52_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_46_258 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_6_333 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0978_ data\[0\]\[9\] data\[1\]\[9\] data\[2\]\[9\] data\[3\]\[9\] _0798_ _0806_
+ VGND VGND VPWR VPWR _0810_ sky130_fd_sc_hd__mux4_1
XFILLER_0_10_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_25_301 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_52_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_37_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_48_448 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1950_ clknet_leaf_18_clk _0090_ VGND VGND VPWR VPWR data\[0\]\[18\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_36_280 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1881_ clknet_leaf_19_clk _0021_ VGND VGND VPWR VPWR data\[2\]\[21\] sky130_fd_sc_hd__dfxtp_1
X_1315_ _0484_ VGND VGND VPWR VPWR _0101_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_63_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1177_ net53 _0393_ _0380_ VGND VGND VPWR VPWR _0394_ sky130_fd_sc_hd__mux2_1
X_1246_ net304 _0446_ net149 VGND VGND VPWR VPWR _0447_ sky130_fd_sc_hd__mux2_1
XFILLER_0_59_361 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_53_484 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_45_429 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1100_ _0904_ VGND VGND VPWR VPWR _0036_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_48_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1031_ _0851_ VGND VGND VPWR VPWR _0020_ sky130_fd_sc_hd__clkbuf_1
X_2080_ clknet_leaf_25_clk _0220_ VGND VGND VPWR VPWR data\[3\]\[4\] sky130_fd_sc_hd__dfxtp_1
X_1933_ clknet_leaf_23_clk _0073_ VGND VGND VPWR VPWR data\[0\]\[1\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_16_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xinput41 wdata[43] VGND VGND VPWR VPWR net41 sky130_fd_sc_hd__clkbuf_1
Xinput30 wdata[33] VGND VGND VPWR VPWR net30 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_58_40 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1795_ _0737_ VGND VGND VPWR VPWR _0328_ sky130_fd_sc_hd__clkbuf_1
Xinput52 wdata[53] VGND VGND VPWR VPWR net52 sky130_fd_sc_hd__buf_1
Xinput74 wdata[8] VGND VGND VPWR VPWR net74 sky130_fd_sc_hd__clkbuf_1
Xinput63 wdata[63] VGND VGND VPWR VPWR net63 sky130_fd_sc_hd__clkbuf_1
X_1864_ clknet_leaf_25_clk _0004_ VGND VGND VPWR VPWR data\[2\]\[4\] sky130_fd_sc_hd__dfxtp_1
X_1229_ net66 _0433_ _0414_ VGND VGND VPWR VPWR _0434_ sky130_fd_sc_hd__mux2_1
XFILLER_0_62_345 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_50_465 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_47_364 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_30_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_7_187 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_53_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1580_ _0624_ VGND VGND VPWR VPWR _0226_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_21_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2201_ clknet_leaf_9_clk _0341_ VGND VGND VPWR VPWR data\[1\]\[53\] sky130_fd_sc_hd__dfxtp_1
X_2132_ clknet_leaf_0_clk _0272_ VGND VGND VPWR VPWR data\[3\]\[56\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_0_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_64_557 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_48_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_44_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2063_ clknet_leaf_2_clk _0203_ VGND VGND VPWR VPWR net131 sky130_fd_sc_hd__dfxtp_1
XPHY_EDGE_ROW_14_Left_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1014_ net12 _0837_ _0814_ VGND VGND VPWR VPWR _0838_ sky130_fd_sc_hd__mux2_1
XFILLER_0_29_364 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1916_ clknet_leaf_0_clk _0056_ VGND VGND VPWR VPWR data\[2\]\[56\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_8_236 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1847_ _0764_ VGND VGND VPWR VPWR _0353_ sky130_fd_sc_hd__clkbuf_1
X_1778_ _0728_ VGND VGND VPWR VPWR _0320_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_4_168 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_39_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_62_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_18_259 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_61_538 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_53_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_53_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_5_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1701_ _0687_ VGND VGND VPWR VPWR _0284_ sky130_fd_sc_hd__clkbuf_1
X_1632_ _0651_ VGND VGND VPWR VPWR _0251_ sky130_fd_sc_hd__clkbuf_1
X_1494_ _0578_ VGND VGND VPWR VPWR _0186_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_53_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_39_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1563_ _0615_ VGND VGND VPWR VPWR _0218_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_55_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2115_ clknet_leaf_9_clk _0255_ VGND VGND VPWR VPWR data\[3\]\[39\] sky130_fd_sc_hd__dfxtp_1
X_2046_ clknet_leaf_8_clk _0186_ VGND VGND VPWR VPWR net113 sky130_fd_sc_hd__dfxtp_1
XFILLER_0_44_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_4_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_4_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_23_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_35_175 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_31_370 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_23_348 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_58_289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_41_32 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_0994_ net235 _0822_ _0816_ VGND VGND VPWR VPWR _0823_ sky130_fd_sc_hd__mux2_1
X_1615_ _0642_ VGND VGND VPWR VPWR _0243_ sky130_fd_sc_hd__clkbuf_1
X_1477_ _0569_ VGND VGND VPWR VPWR _0178_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_5_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1546_ _0605_ VGND VGND VPWR VPWR _0211_ sky130_fd_sc_hd__clkbuf_1
X_2029_ clknet_leaf_16_clk _0169_ VGND VGND VPWR VPWR net94 sky130_fd_sc_hd__dfxtp_1
XPHY_EDGE_ROW_17_Left_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold260 data\[0\]\[34\] VGND VGND VPWR VPWR net411 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_32_112 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xhold271 data\[2\]\[56\] VGND VGND VPWR VPWR net422 sky130_fd_sc_hd__dlygate4sd3_1
Xhold282 data\[3\]\[4\] VGND VGND VPWR VPWR net433 sky130_fd_sc_hd__dlygate4sd3_1
Xhold293 net137 VGND VGND VPWR VPWR net444 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_28_321 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_63_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_11_210 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_23_156 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1331_ net194 _0906_ _0485_ VGND VGND VPWR VPWR _0493_ sky130_fd_sc_hd__mux2_1
X_1400_ net366 _0446_ net151 VGND VGND VPWR VPWR _0529_ sky130_fd_sc_hd__mux2_1
XFILLER_0_11_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xinput6 wdata[11] VGND VGND VPWR VPWR net6 sky130_fd_sc_hd__clkbuf_1
X_1262_ net282 _0792_ _0452_ VGND VGND VPWR VPWR _0457_ sky130_fd_sc_hd__mux2_1
X_1193_ net2 VGND VGND VPWR VPWR _0406_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_61_207 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_34_357 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_54_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_6_345 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0977_ _0809_ VGND VGND VPWR VPWR _0008_ sky130_fd_sc_hd__clkbuf_1
X_1529_ _0596_ VGND VGND VPWR VPWR _0203_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_25_302 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_45_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_2_Left_67 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_14_Right_14 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_20_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_23_Right_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_48_449 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1880_ clknet_leaf_16_clk _0020_ VGND VGND VPWR VPWR data\[2\]\[20\] sky130_fd_sc_hd__dfxtp_1
XPHY_EDGE_ROW_32_Right_32 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_31_338 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_28_204 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_3_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1314_ net390 _0879_ _0474_ VGND VGND VPWR VPWR _0484_ sky130_fd_sc_hd__mux2_1
XPHY_EDGE_ROW_41_Right_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_11_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_59_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_50_Right_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1245_ net71 _0445_ _0774_ VGND VGND VPWR VPWR _0446_ sky130_fd_sc_hd__mux2_1
X_1176_ data\[0\]\[54\] data\[1\]\[54\] data\[2\]\[54\] data\[3\]\[54\] _0365_ _0372_
+ VGND VGND VPWR VPWR _0393_ sky130_fd_sc_hd__mux4_1
Xoutput140 net140 VGND VGND VPWR VPWR rdata[67] sky130_fd_sc_hd__clkbuf_4
XTAP_TAPCELL_ROW_53_485 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_25_207 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_33_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_0_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1030_ net420 _0849_ _0850_ VGND VGND VPWR VPWR _0851_ sky130_fd_sc_hd__mux2_1
XFILLER_0_17_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xinput20 wdata[24] VGND VGND VPWR VPWR net20 sky130_fd_sc_hd__buf_1
XFILLER_0_56_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_56_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xinput31 wdata[34] VGND VGND VPWR VPWR net31 sky130_fd_sc_hd__buf_1
X_1863_ clknet_leaf_25_clk _0003_ VGND VGND VPWR VPWR data\[2\]\[3\] sky130_fd_sc_hd__dfxtp_1
X_1932_ clknet_leaf_23_clk _0072_ VGND VGND VPWR VPWR data\[0\]\[0\] sky130_fd_sc_hd__dfxtp_1
Xinput42 wdata[44] VGND VGND VPWR VPWR net42 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_58_63 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1794_ net275 _0917_ _0736_ VGND VGND VPWR VPWR _0737_ sky130_fd_sc_hd__mux2_1
Xinput53 wdata[54] VGND VGND VPWR VPWR net53 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_24_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xinput64 wdata[64] VGND VGND VPWR VPWR net64 sky130_fd_sc_hd__clkbuf_1
Xinput75 wdata[9] VGND VGND VPWR VPWR net75 sky130_fd_sc_hd__buf_1
XFILLER_0_58_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1228_ data\[0\]\[66\] data\[1\]\[66\] data\[2\]\[66\] data\[3\]\[66\] _0797_ _0406_
+ VGND VGND VPWR VPWR _0433_ sky130_fd_sc_hd__mux4_1
XFILLER_0_47_354 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_47_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1159_ _0774_ VGND VGND VPWR VPWR _0380_ sky130_fd_sc_hd__buf_4
XFILLER_0_62_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_50_466 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_57_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_38_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_leaf_23_clk clknet_2_2__leaf_clk VGND VGND VPWR VPWR clknet_leaf_23_clk sky130_fd_sc_hd__clkbuf_8
XPHY_EDGE_ROW_5_Left_70 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_0_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_0_126 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2200_ clknet_leaf_3_clk _0340_ VGND VGND VPWR VPWR data\[1\]\[52\] sky130_fd_sc_hd__dfxtp_1
X_2131_ clknet_leaf_4_clk _0271_ VGND VGND VPWR VPWR data\[3\]\[55\] sky130_fd_sc_hd__dfxtp_1
X_2062_ clknet_leaf_0_clk _0202_ VGND VGND VPWR VPWR net130 sky130_fd_sc_hd__dfxtp_1
XFILLER_0_28_66 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_64_558 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_48_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1013_ data\[0\]\[17\] data\[1\]\[17\] data\[2\]\[17\] data\[3\]\[17\] _0833_ _0806_
+ VGND VGND VPWR VPWR _0837_ sky130_fd_sc_hd__mux4_1
XFILLER_0_60_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_56_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1777_ net223 _0890_ _0725_ VGND VGND VPWR VPWR _0728_ sky130_fd_sc_hd__mux2_1
Xclkbuf_leaf_14_clk clknet_2_3__leaf_clk VGND VGND VPWR VPWR clknet_leaf_14_clk sky130_fd_sc_hd__clkbuf_8
X_1915_ clknet_leaf_4_clk _0055_ VGND VGND VPWR VPWR data\[2\]\[55\] sky130_fd_sc_hd__dfxtp_1
X_1846_ net419 _0431_ _0758_ VGND VGND VPWR VPWR _0764_ sky130_fd_sc_hd__mux2_1
XPHY_EDGE_ROW_4_Right_4 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_8_76 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_12_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_35_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_35_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_7_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_7_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_31_Left_96 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_14_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1631_ net283 _0899_ _0645_ VGND VGND VPWR VPWR _0651_ sky130_fd_sc_hd__mux2_1
XFILLER_0_38_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_30_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_30_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_26_324 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1700_ net173 _0440_ _0678_ VGND VGND VPWR VPWR _0687_ sky130_fd_sc_hd__mux2_1
X_1493_ net459 _0923_ _0575_ VGND VGND VPWR VPWR _0578_ sky130_fd_sc_hd__mux2_1
Xclkbuf_leaf_3_clk clknet_2_1__leaf_clk VGND VGND VPWR VPWR clknet_leaf_3_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_0_39_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1562_ net262 _0786_ _0612_ VGND VGND VPWR VPWR _0615_ sky130_fd_sc_hd__mux2_1
X_2045_ clknet_leaf_9_clk _0185_ VGND VGND VPWR VPWR net112 sky130_fd_sc_hd__dfxtp_1
X_2114_ clknet_leaf_9_clk _0254_ VGND VGND VPWR VPWR data\[3\]\[38\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_29_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_17_324 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xmax_cap150 _0691_ VGND VGND VPWR VPWR net150 sky130_fd_sc_hd__buf_2
X_1829_ net284 _0404_ _0747_ VGND VGND VPWR VPWR _0755_ sky130_fd_sc_hd__mux2_1
XFILLER_0_35_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_25_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_0993_ net7 _0821_ _0814_ VGND VGND VPWR VPWR _0822_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_14_230 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1614_ net432 _0872_ _0634_ VGND VGND VPWR VPWR _0642_ sky130_fd_sc_hd__mux2_1
X_1476_ net495 _0895_ _0564_ VGND VGND VPWR VPWR _0569_ sky130_fd_sc_hd__mux2_1
X_1545_ net481 _0436_ _0597_ VGND VGND VPWR VPWR _0605_ sky130_fd_sc_hd__mux2_1
X_2028_ clknet_leaf_16_clk _0168_ VGND VGND VPWR VPWR net93 sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_37_377 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_10_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold283 data\[3\]\[41\] VGND VGND VPWR VPWR net434 sky130_fd_sc_hd__dlygate4sd3_1
Xhold272 data\[0\]\[22\] VGND VGND VPWR VPWR net423 sky130_fd_sc_hd__dlygate4sd3_1
Xhold294 data\[2\]\[55\] VGND VGND VPWR VPWR net445 sky130_fd_sc_hd__dlygate4sd3_1
Xhold250 data\[2\]\[57\] VGND VGND VPWR VPWR net401 sky130_fd_sc_hd__dlygate4sd3_1
Xhold261 data\[0\]\[9\] VGND VGND VPWR VPWR net412 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_20_266 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_28_322 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_63_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_36 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_11_211 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_11_308 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_23_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_23_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1330_ _0492_ VGND VGND VPWR VPWR _0108_ sky130_fd_sc_hd__clkbuf_1
X_1261_ _0456_ VGND VGND VPWR VPWR _0075_ sky130_fd_sc_hd__clkbuf_1
Xinput7 wdata[12] VGND VGND VPWR VPWR net7 sky130_fd_sc_hd__clkbuf_1
X_1192_ _0405_ VGND VGND VPWR VPWR _0057_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_34_358 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_6_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_0976_ net300 _0808_ _0780_ VGND VGND VPWR VPWR _0809_ sky130_fd_sc_hd__mux2_1
XFILLER_0_58_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1459_ net421 _0868_ _0553_ VGND VGND VPWR VPWR _0560_ sky130_fd_sc_hd__mux2_1
X_1528_ net131 _0410_ _0586_ VGND VGND VPWR VPWR _0596_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_25_303 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_31_339 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_22_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_3_349 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_3_305 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1313_ _0483_ VGND VGND VPWR VPWR _0100_ sky130_fd_sc_hd__clkbuf_1
X_1244_ data\[0\]\[70\] data\[1\]\[70\] data\[2\]\[70\] data\[3\]\[70\] _0797_ _0805_
+ VGND VGND VPWR VPWR _0445_ sky130_fd_sc_hd__mux4_1
X_1175_ _0392_ VGND VGND VPWR VPWR _0053_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_19_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_6_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_0959_ net59 _0794_ _0775_ VGND VGND VPWR VPWR _0795_ sky130_fd_sc_hd__mux2_1
Xoutput141 net141 VGND VGND VPWR VPWR rdata[68] sky130_fd_sc_hd__clkbuf_4
Xoutput130 net130 VGND VGND VPWR VPWR rdata[58] sky130_fd_sc_hd__clkbuf_4
XTAP_TAPCELL_ROW_53_486 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_17_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xinput43 wdata[45] VGND VGND VPWR VPWR net43 sky130_fd_sc_hd__clkbuf_1
Xinput32 wdata[35] VGND VGND VPWR VPWR net32 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_56_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_56_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1793_ net150 VGND VGND VPWR VPWR _0736_ sky130_fd_sc_hd__buf_4
Xinput54 wdata[55] VGND VGND VPWR VPWR net54 sky130_fd_sc_hd__clkbuf_1
Xinput21 wdata[25] VGND VGND VPWR VPWR net21 sky130_fd_sc_hd__clkbuf_1
X_1931_ clknet_leaf_17_clk _0071_ VGND VGND VPWR VPWR data\[2\]\[71\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_24_230 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_3_113 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1862_ clknet_leaf_26_clk _0002_ VGND VGND VPWR VPWR data\[2\]\[2\] sky130_fd_sc_hd__dfxtp_1
Xinput10 wdata[15] VGND VGND VPWR VPWR net10 sky130_fd_sc_hd__clkbuf_1
Xinput76 wr VGND VGND VPWR VPWR net76 sky130_fd_sc_hd__buf_1
Xinput65 wdata[65] VGND VGND VPWR VPWR net65 sky130_fd_sc_hd__clkbuf_1
X_1158_ data\[0\]\[50\] data\[1\]\[50\] data\[2\]\[50\] data\[3\]\[50\] _0365_ _0372_
+ VGND VGND VPWR VPWR _0379_ sky130_fd_sc_hd__mux4_1
X_1227_ _0432_ VGND VGND VPWR VPWR _0065_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_50_467 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_47_322 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1089_ net31 _0895_ _0882_ VGND VGND VPWR VPWR _0896_ sky130_fd_sc_hd__mux2_1
XFILLER_0_30_211 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_15_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_53_314 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_44_Left_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_28_12 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_53_Left_118 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2130_ clknet_leaf_4_clk _0270_ VGND VGND VPWR VPWR data\[3\]\[54\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_28_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_28_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1012_ _0836_ VGND VGND VPWR VPWR _0016_ sky130_fd_sc_hd__clkbuf_1
X_2061_ clknet_leaf_0_clk _0201_ VGND VGND VPWR VPWR net129 sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_64_559 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1914_ clknet_leaf_4_clk _0054_ VGND VGND VPWR VPWR data\[2\]\[54\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_29_300 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_8_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1776_ _0727_ VGND VGND VPWR VPWR _0319_ sky130_fd_sc_hd__clkbuf_1
XPHY_EDGE_ROW_62_Left_127 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_44_336 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1845_ _0763_ VGND VGND VPWR VPWR _0352_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_12_211 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_50_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_38_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_53_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1630_ _0650_ VGND VGND VPWR VPWR _0250_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_41_328 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1492_ _0577_ VGND VGND VPWR VPWR _0185_ sky130_fd_sc_hd__clkbuf_1
X_1561_ _0614_ VGND VGND VPWR VPWR _0217_ sky130_fd_sc_hd__clkbuf_1
X_2113_ clknet_leaf_8_clk _0253_ VGND VGND VPWR VPWR data\[3\]\[37\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_55_87 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_55_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2044_ clknet_leaf_6_clk _0184_ VGND VGND VPWR VPWR net111 sky130_fd_sc_hd__dfxtp_1
XFILLER_0_44_144 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_29_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_17_250 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_44_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1759_ _0718_ VGND VGND VPWR VPWR _0311_ sky130_fd_sc_hd__clkbuf_1
Xmax_cap151 _0451_ VGND VGND VPWR VPWR net151 sky130_fd_sc_hd__buf_2
X_1828_ _0754_ VGND VGND VPWR VPWR _0344_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_0_140 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_50_114 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_35_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_35_122 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_35_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_23_286 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_0992_ data\[0\]\[12\] data\[1\]\[12\] data\[2\]\[12\] data\[3\]\[12\] _0798_ _0806_
+ VGND VGND VPWR VPWR _0821_ sky130_fd_sc_hd__mux4_1
XTAP_TAPCELL_ROW_14_231 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1613_ _0641_ VGND VGND VPWR VPWR _0242_ sky130_fd_sc_hd__clkbuf_1
X_1544_ _0604_ VGND VGND VPWR VPWR _0210_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_14_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1475_ _0568_ VGND VGND VPWR VPWR _0177_ sky130_fd_sc_hd__clkbuf_1
X_2027_ clknet_leaf_14_clk _0167_ VGND VGND VPWR VPWR net92 sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_37_378 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_20_267 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xhold295 data\[3\]\[26\] VGND VGND VPWR VPWR net446 sky130_fd_sc_hd__dlygate4sd3_1
Xhold262 data\[3\]\[22\] VGND VGND VPWR VPWR net413 sky130_fd_sc_hd__dlygate4sd3_1
Xhold284 data\[0\]\[53\] VGND VGND VPWR VPWR net435 sky130_fd_sc_hd__dlygate4sd3_1
Xhold251 data\[2\]\[53\] VGND VGND VPWR VPWR net402 sky130_fd_sc_hd__dlygate4sd3_1
Xhold240 data\[0\]\[19\] VGND VGND VPWR VPWR net391 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_20_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xhold273 data\[0\]\[57\] VGND VGND VPWR VPWR net424 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_28_323 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_11_212 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_23_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_36_12 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_31_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xinput8 wdata[13] VGND VGND VPWR VPWR net8 sky130_fd_sc_hd__clkbuf_1
X_1260_ net347 _0789_ _0452_ VGND VGND VPWR VPWR _0456_ sky130_fd_sc_hd__mux2_1
X_1191_ net401 _0404_ _0382_ VGND VGND VPWR VPWR _0405_ sky130_fd_sc_hd__mux2_1
XFILLER_0_52_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_36_67 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_54_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_46_228 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_34_359 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_14_114 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_0975_ net74 _0807_ _0775_ VGND VGND VPWR VPWR _0808_ sky130_fd_sc_hd__mux2_1
X_1527_ _0595_ VGND VGND VPWR VPWR _0202_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_10_342 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1458_ _0559_ VGND VGND VPWR VPWR _0169_ sky130_fd_sc_hd__clkbuf_1
X_1389_ _0523_ VGND VGND VPWR VPWR _0136_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_25_304 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_9_152 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_60_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_20_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_20_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_3_317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1312_ net236 _0876_ _0474_ VGND VGND VPWR VPWR _0483_ sky130_fd_sc_hd__mux2_1
X_1174_ net402 _0391_ _0382_ VGND VGND VPWR VPWR _0392_ sky130_fd_sc_hd__mux2_1
X_1243_ _0444_ VGND VGND VPWR VPWR _0069_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_42_286 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_0958_ data\[0\]\[5\] data\[1\]\[5\] data\[2\]\[5\] data\[3\]\[5\] _0771_ _0772_
+ VGND VGND VPWR VPWR _0794_ sky130_fd_sc_hd__mux4_1
Xoutput120 net120 VGND VGND VPWR VPWR rdata[49] sky130_fd_sc_hd__clkbuf_4
Xoutput142 net142 VGND VGND VPWR VPWR rdata[69] sky130_fd_sc_hd__clkbuf_4
Xoutput131 net131 VGND VGND VPWR VPWR rdata[59] sky130_fd_sc_hd__clkbuf_4
XFILLER_0_18_294 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_33_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_0_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_36 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1930_ clknet_leaf_2_clk _0070_ VGND VGND VPWR VPWR data\[2\]\[70\] sky130_fd_sc_hd__dfxtp_1
Xinput33 wdata[36] VGND VGND VPWR VPWR net33 sky130_fd_sc_hd__clkbuf_1
Xinput22 wdata[26] VGND VGND VPWR VPWR net22 sky130_fd_sc_hd__clkbuf_1
Xinput44 wdata[46] VGND VGND VPWR VPWR net44 sky130_fd_sc_hd__clkbuf_1
X_1792_ _0735_ VGND VGND VPWR VPWR _0327_ sky130_fd_sc_hd__clkbuf_1
Xinput11 wdata[16] VGND VGND VPWR VPWR net11 sky130_fd_sc_hd__clkbuf_1
Xinput55 wdata[56] VGND VGND VPWR VPWR net55 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_3_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xinput66 wdata[66] VGND VGND VPWR VPWR net66 sky130_fd_sc_hd__clkbuf_1
X_1861_ clknet_leaf_27_clk _0001_ VGND VGND VPWR VPWR data\[2\]\[1\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_58_32 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1157_ _0378_ VGND VGND VPWR VPWR _0049_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_35_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1226_ net247 _0431_ _0416_ VGND VGND VPWR VPWR _0432_ sky130_fd_sc_hd__mux2_1
X_1088_ data\[0\]\[34\] data\[1\]\[34\] data\[2\]\[34\] data\[3\]\[34\] _0867_ _0874_
+ VGND VGND VPWR VPWR _0895_ sky130_fd_sc_hd__mux4_1
XFILLER_0_15_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_58_513 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_53_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_28_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_0_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_44_67 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2060_ clknet_leaf_0_clk _0200_ VGND VGND VPWR VPWR net128 sky130_fd_sc_hd__dfxtp_1
X_1011_ net217 _0835_ _0816_ VGND VGND VPWR VPWR _0836_ sky130_fd_sc_hd__mux2_1
XFILLER_0_56_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_44_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1913_ clknet_leaf_2_clk _0053_ VGND VGND VPWR VPWR data\[2\]\[53\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_29_312 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1775_ net417 _0887_ _0725_ VGND VGND VPWR VPWR _0727_ sky130_fd_sc_hd__mux2_1
X_1844_ net240 _0428_ _0758_ VGND VGND VPWR VPWR _0763_ sky130_fd_sc_hd__mux2_1
XFILLER_0_12_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2189_ clknet_leaf_9_clk _0329_ VGND VGND VPWR VPWR data\[1\]\[41\] sky130_fd_sc_hd__dfxtp_1
X_1209_ net61 _0418_ _0414_ VGND VGND VPWR VPWR _0419_ sky130_fd_sc_hd__mux2_1
XFILLER_0_62_156 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_50_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_47_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_47_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_35_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_3_160 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_38_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_14_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1560_ net169 _0783_ _0612_ VGND VGND VPWR VPWR _0614_ sky130_fd_sc_hd__mux2_1
X_2112_ clknet_leaf_8_clk _0252_ VGND VGND VPWR VPWR data\[3\]\[36\] sky130_fd_sc_hd__dfxtp_1
X_1491_ net487 _0920_ _0575_ VGND VGND VPWR VPWR _0577_ sky130_fd_sc_hd__mux2_1
X_2043_ clknet_leaf_9_clk _0183_ VGND VGND VPWR VPWR net109 sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_17_251 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_60_530 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_44_156 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_32_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1827_ net371 _0401_ _0747_ VGND VGND VPWR VPWR _0754_ sky130_fd_sc_hd__mux2_1
X_1758_ net320 _0859_ _0714_ VGND VGND VPWR VPWR _0718_ sky130_fd_sc_hd__mux2_1
X_1689_ _0681_ VGND VGND VPWR VPWR _0278_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_0_141 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_130 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_35_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_23_287 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_25_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_41_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_41_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_26_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_0991_ _0820_ VGND VGND VPWR VPWR _0011_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_14_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_14_232 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1474_ net463 _0892_ _0564_ VGND VGND VPWR VPWR _0568_ sky130_fd_sc_hd__mux2_1
X_1612_ net446 _0869_ _0634_ VGND VGND VPWR VPWR _0641_ sky130_fd_sc_hd__mux2_1
XFILLER_0_1_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_1_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1543_ net461 _0433_ _0597_ VGND VGND VPWR VPWR _0604_ sky130_fd_sc_hd__mux2_1
XFILLER_0_5_68 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_57_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2026_ clknet_leaf_14_clk _0166_ VGND VGND VPWR VPWR net91 sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_37_379 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_13_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_20_268 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xhold263 net105 VGND VGND VPWR VPWR net414 sky130_fd_sc_hd__dlygate4sd3_1
Xhold296 net101 VGND VGND VPWR VPWR net447 sky130_fd_sc_hd__dlygate4sd3_1
Xhold274 net91 VGND VGND VPWR VPWR net425 sky130_fd_sc_hd__dlygate4sd3_1
Xhold252 data\[0\]\[1\] VGND VGND VPWR VPWR net403 sky130_fd_sc_hd__dlygate4sd3_1
Xhold230 data\[2\]\[67\] VGND VGND VPWR VPWR net381 sky130_fd_sc_hd__dlygate4sd3_1
Xhold285 data\[0\]\[13\] VGND VGND VPWR VPWR net436 sky130_fd_sc_hd__dlygate4sd3_1
Xhold241 data\[0\]\[58\] VGND VGND VPWR VPWR net392 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_28_324 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_55_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_55_207 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_11_213 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_36_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_36_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1190_ net56 _0403_ _0380_ VGND VGND VPWR VPWR _0404_ sky130_fd_sc_hd__mux2_1
Xinput9 wdata[14] VGND VGND VPWR VPWR net9 sky130_fd_sc_hd__clkbuf_1
X_0974_ data\[0\]\[8\] data\[1\]\[8\] data\[2\]\[8\] data\[3\]\[8\] _0798_ _0806_
+ VGND VGND VPWR VPWR _0807_ sky130_fd_sc_hd__mux4_1
X_1457_ net498 _0864_ _0553_ VGND VGND VPWR VPWR _0559_ sky130_fd_sc_hd__mux2_1
X_1526_ net499 _0407_ _0586_ VGND VGND VPWR VPWR _0595_ sky130_fd_sc_hd__mux2_1
XFILLER_0_10_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1388_ net380 _0428_ _0518_ VGND VGND VPWR VPWR _0523_ sky130_fd_sc_hd__mux2_1
XFILLER_0_9_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2009_ clknet_leaf_23_clk _0149_ VGND VGND VPWR VPWR net132 sky130_fd_sc_hd__dfxtp_1
XFILLER_0_60_265 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_51_243 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_51_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_3_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_51_298 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1311_ _0482_ VGND VGND VPWR VPWR _0099_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_63_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1173_ net52 _0390_ _0380_ VGND VGND VPWR VPWR _0391_ sky130_fd_sc_hd__mux2_1
XFILLER_0_2_58 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_10_Right_10 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1242_ net271 _0443_ _0416_ VGND VGND VPWR VPWR _0444_ sky130_fd_sc_hd__mux2_1
XFILLER_0_19_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_63_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput143 net143 VGND VGND VPWR VPWR rdata[6] sky130_fd_sc_hd__clkbuf_4
Xoutput132 net132 VGND VGND VPWR VPWR rdata[5] sky130_fd_sc_hd__clkbuf_4
Xoutput121 net121 VGND VGND VPWR VPWR rdata[4] sky130_fd_sc_hd__clkbuf_4
XFILLER_0_6_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_0957_ _0793_ VGND VGND VPWR VPWR _0004_ sky130_fd_sc_hd__clkbuf_1
Xoutput110 net110 VGND VGND VPWR VPWR rdata[3] sky130_fd_sc_hd__buf_2
X_1509_ _0778_ VGND VGND VPWR VPWR _0586_ sky130_fd_sc_hd__buf_4
XFILLER_0_33_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_44_422 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1860_ clknet_leaf_27_clk _0000_ VGND VGND VPWR VPWR data\[2\]\[0\] sky130_fd_sc_hd__dfxtp_1
Xclkbuf_leaf_26_clk clknet_2_0__leaf_clk VGND VGND VPWR VPWR clknet_leaf_26_clk sky130_fd_sc_hd__clkbuf_8
Xinput34 wdata[37] VGND VGND VPWR VPWR net34 sky130_fd_sc_hd__clkbuf_1
Xinput23 wdata[27] VGND VGND VPWR VPWR net23 sky130_fd_sc_hd__clkbuf_1
X_1791_ net332 _0913_ _0725_ VGND VGND VPWR VPWR _0735_ sky130_fd_sc_hd__mux2_1
Xinput45 wdata[47] VGND VGND VPWR VPWR net45 sky130_fd_sc_hd__clkbuf_1
Xinput56 wdata[57] VGND VGND VPWR VPWR net56 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_24_287 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_24_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xinput67 wdata[67] VGND VGND VPWR VPWR net67 sky130_fd_sc_hd__clkbuf_1
Xinput12 wdata[17] VGND VGND VPWR VPWR net12 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_59_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1087_ _0894_ VGND VGND VPWR VPWR _0033_ sky130_fd_sc_hd__clkbuf_1
X_1156_ net264 _0377_ _0918_ VGND VGND VPWR VPWR _0378_ sky130_fd_sc_hd__mux2_1
Xclkbuf_leaf_17_clk clknet_2_2__leaf_clk VGND VGND VPWR VPWR clknet_leaf_17_clk sky130_fd_sc_hd__clkbuf_8
X_1225_ net65 _0430_ _0414_ VGND VGND VPWR VPWR _0431_ sky130_fd_sc_hd__mux2_1
XFILLER_0_62_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_59_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1989_ clknet_leaf_0_clk _0129_ VGND VGND VPWR VPWR data\[0\]\[57\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_15_210 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_15_298 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_58_514 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_41_403 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_44_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1010_ net11 _0834_ _0814_ VGND VGND VPWR VPWR _0835_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_6_180 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_44_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1912_ clknet_leaf_4_clk _0052_ VGND VGND VPWR VPWR data\[2\]\[52\] sky130_fd_sc_hd__dfxtp_1
X_1843_ _0762_ VGND VGND VPWR VPWR _0351_ sky130_fd_sc_hd__clkbuf_1
Xclkbuf_leaf_6_clk clknet_2_1__leaf_clk VGND VGND VPWR VPWR clknet_leaf_6_clk sky130_fd_sc_hd__clkbuf_8
X_1774_ _0726_ VGND VGND VPWR VPWR _0318_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_8_46 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_12_235 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_26_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1208_ data\[0\]\[61\] data\[1\]\[61\] data\[2\]\[61\] data\[3\]\[61\] _0399_ _0406_
+ VGND VGND VPWR VPWR _0418_ sky130_fd_sc_hd__mux4_1
XTAP_TAPCELL_ROW_63_550 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1139_ _0364_ VGND VGND VPWR VPWR _0045_ sky130_fd_sc_hd__clkbuf_1
X_2188_ clknet_leaf_3_clk _0328_ VGND VGND VPWR VPWR data\[1\]\[40\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_62_124 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_35_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_35_327 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_3_161 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_9_Left_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_53_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1490_ _0576_ VGND VGND VPWR VPWR _0184_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_39_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2111_ clknet_leaf_12_clk _0251_ VGND VGND VPWR VPWR data\[3\]\[35\] sky130_fd_sc_hd__dfxtp_1
Xhold1 data\[1\]\[45\] VGND VGND VPWR VPWR net152 sky130_fd_sc_hd__dlygate4sd3_1
X_2042_ clknet_leaf_10_clk _0182_ VGND VGND VPWR VPWR net108 sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_60_531 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_8_Right_8 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_17_252 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_44_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1826_ _0753_ VGND VGND VPWR VPWR _0343_ sky130_fd_sc_hd__clkbuf_1
X_1757_ _0717_ VGND VGND VPWR VPWR _0310_ sky130_fd_sc_hd__clkbuf_1
XPHY_EDGE_ROW_39_Right_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_40_374 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_40_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1688_ net225 _0422_ _0678_ VGND VGND VPWR VPWR _0681_ sky130_fd_sc_hd__mux2_1
XFILLER_0_29_90 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_0_142 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_0_131 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_48_Right_48 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_0_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_23_288 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_57_Right_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_31_374 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1611_ _0640_ VGND VGND VPWR VPWR _0241_ sky130_fd_sc_hd__clkbuf_1
X_0990_ net185 _0819_ _0816_ VGND VGND VPWR VPWR _0820_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_14_233 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1473_ _0567_ VGND VGND VPWR VPWR _0176_ sky130_fd_sc_hd__clkbuf_1
X_1542_ _0603_ VGND VGND VPWR VPWR _0209_ sky130_fd_sc_hd__clkbuf_1
X_2025_ clknet_leaf_15_clk _0165_ VGND VGND VPWR VPWR net90 sky130_fd_sc_hd__dfxtp_1
XFILLER_0_64_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_59_Left_124 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold231 net115 VGND VGND VPWR VPWR net382 sky130_fd_sc_hd__dlygate4sd3_1
X_1809_ _0744_ VGND VGND VPWR VPWR _0335_ sky130_fd_sc_hd__clkbuf_1
Xhold253 data\[0\]\[55\] VGND VGND VPWR VPWR net404 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_32_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xhold220 data\[1\]\[56\] VGND VGND VPWR VPWR net371 sky130_fd_sc_hd__dlygate4sd3_1
Xhold242 data\[2\]\[58\] VGND VGND VPWR VPWR net393 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_20_269 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xhold286 net114 VGND VGND VPWR VPWR net437 sky130_fd_sc_hd__dlygate4sd3_1
Xhold297 data\[3\]\[24\] VGND VGND VPWR VPWR net448 sky130_fd_sc_hd__dlygate4sd3_1
Xhold264 data\[3\]\[51\] VGND VGND VPWR VPWR net415 sky130_fd_sc_hd__dlygate4sd3_1
Xhold275 data\[2\]\[6\] VGND VGND VPWR VPWR net426 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_55_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_0973_ _0805_ VGND VGND VPWR VPWR _0806_ sky130_fd_sc_hd__clkbuf_4
X_1456_ _0558_ VGND VGND VPWR VPWR _0168_ sky130_fd_sc_hd__clkbuf_1
X_1525_ _0594_ VGND VGND VPWR VPWR _0201_ sky130_fd_sc_hd__clkbuf_1
X_1387_ _0522_ VGND VGND VPWR VPWR _0135_ sky130_fd_sc_hd__clkbuf_1
X_2008_ clknet_leaf_24_clk _0148_ VGND VGND VPWR VPWR net121 sky130_fd_sc_hd__dfxtp_1
XFILLER_0_9_187 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_60_277 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_51_255 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_51_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_36_274 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1310_ net348 _0872_ _0474_ VGND VGND VPWR VPWR _0482_ sky130_fd_sc_hd__mux2_1
XFILLER_0_47_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1241_ net69 _0442_ _0414_ VGND VGND VPWR VPWR _0443_ sky130_fd_sc_hd__mux2_1
XPHY_EDGE_ROW_22_Left_87 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_47_442 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1172_ data\[0\]\[53\] data\[1\]\[53\] data\[2\]\[53\] data\[3\]\[53\] _0365_ _0372_
+ VGND VGND VPWR VPWR _0390_ sky130_fd_sc_hd__mux4_1
XFILLER_0_2_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_2_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_30_331 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_6_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_6_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_0956_ net280 _0792_ _0780_ VGND VGND VPWR VPWR _0793_ sky130_fd_sc_hd__mux2_1
Xoutput100 net100 VGND VGND VPWR VPWR rdata[30] sky130_fd_sc_hd__clkbuf_4
Xoutput111 net111 VGND VGND VPWR VPWR rdata[40] sky130_fd_sc_hd__clkbuf_4
XFILLER_0_56_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_42_299 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xoutput144 net144 VGND VGND VPWR VPWR rdata[70] sky130_fd_sc_hd__clkbuf_4
Xoutput122 net122 VGND VGND VPWR VPWR rdata[50] sky130_fd_sc_hd__clkbuf_4
XFILLER_0_2_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xoutput133 net133 VGND VGND VPWR VPWR rdata[60] sky130_fd_sc_hd__clkbuf_4
XFILLER_0_12_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1508_ _0585_ VGND VGND VPWR VPWR _0193_ sky130_fd_sc_hd__clkbuf_1
X_1439_ _0549_ VGND VGND VPWR VPWR _0160_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_44_423 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1790_ _0734_ VGND VGND VPWR VPWR _0326_ sky130_fd_sc_hd__clkbuf_1
Xinput13 wdata[18] VGND VGND VPWR VPWR net13 sky130_fd_sc_hd__clkbuf_1
Xinput35 wdata[38] VGND VGND VPWR VPWR net35 sky130_fd_sc_hd__clkbuf_1
Xinput24 wdata[28] VGND VGND VPWR VPWR net24 sky130_fd_sc_hd__clkbuf_1
Xinput46 wdata[48] VGND VGND VPWR VPWR net46 sky130_fd_sc_hd__clkbuf_1
Xinput68 wdata[68] VGND VGND VPWR VPWR net68 sky130_fd_sc_hd__clkbuf_1
Xinput57 wdata[58] VGND VGND VPWR VPWR net57 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_58_67 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_42_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1224_ data\[0\]\[65\] data\[1\]\[65\] data\[2\]\[65\] data\[3\]\[65\] _0399_ _0406_
+ VGND VGND VPWR VPWR _0430_ sky130_fd_sc_hd__mux4_1
XFILLER_0_59_152 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1086_ net318 _0893_ _0884_ VGND VGND VPWR VPWR _0894_ sky130_fd_sc_hd__mux2_1
X_1155_ net47 _0376_ _0916_ VGND VGND VPWR VPWR _0377_ sky130_fd_sc_hd__mux2_1
XFILLER_0_30_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1988_ clknet_leaf_0_clk _0128_ VGND VGND VPWR VPWR data\[0\]\[56\] sky130_fd_sc_hd__dfxtp_1
X_0939_ _0779_ VGND VGND VPWR VPWR _0780_ sky130_fd_sc_hd__buf_4
XFILLER_0_30_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_58_515 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_2_2__f_clk clknet_0_clk VGND VGND VPWR VPWR clknet_2_2__leaf_clk sky130_fd_sc_hd__clkbuf_16
XTAP_TAPCELL_ROW_41_404 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_38_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_61_361 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_6_181 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_56_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_29_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1773_ net278 _0883_ _0725_ VGND VGND VPWR VPWR _0726_ sky130_fd_sc_hd__mux2_1
X_1911_ clknet_leaf_2_clk _0051_ VGND VGND VPWR VPWR data\[2\]\[51\] sky130_fd_sc_hd__dfxtp_1
X_1842_ net174 _0425_ _0758_ VGND VGND VPWR VPWR _0762_ sky130_fd_sc_hd__mux2_1
XFILLER_0_8_58 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2187_ clknet_leaf_9_clk _0327_ VGND VGND VPWR VPWR data\[1\]\[39\] sky130_fd_sc_hd__dfxtp_1
XPHY_EDGE_ROW_40_Left_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_25_Left_90 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1207_ _0417_ VGND VGND VPWR VPWR _0060_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_63_551 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1069_ _0880_ VGND VGND VPWR VPWR _0029_ sky130_fd_sc_hd__clkbuf_1
X_1138_ net166 _0363_ _0918_ VGND VGND VPWR VPWR _0364_ sky130_fd_sc_hd__mux2_1
XFILLER_0_62_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_50_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_47_199 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_53_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_30_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2041_ clknet_leaf_8_clk _0181_ VGND VGND VPWR VPWR net107 sky130_fd_sc_hd__dfxtp_1
XFILLER_0_55_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2110_ clknet_leaf_10_clk _0250_ VGND VGND VPWR VPWR data\[3\]\[34\] sky130_fd_sc_hd__dfxtp_1
Xhold2 data\[1\]\[11\] VGND VGND VPWR VPWR net153 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_60_532 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1756_ net365 _0856_ _0714_ VGND VGND VPWR VPWR _0717_ sky130_fd_sc_hd__mux2_1
X_1825_ net276 _0397_ _0747_ VGND VGND VPWR VPWR _0753_ sky130_fd_sc_hd__mux2_1
X_1687_ _0680_ VGND VGND VPWR VPWR _0277_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_0_132 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_35_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_35_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_0_70 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_23_289 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_8_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1610_ net339 _0865_ _0634_ VGND VGND VPWR VPWR _0640_ sky130_fd_sc_hd__mux2_1
XFILLER_0_34_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1472_ net484 _0889_ _0564_ VGND VGND VPWR VPWR _0567_ sky130_fd_sc_hd__mux2_1
XFILLER_0_5_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1541_ net460 _0430_ _0597_ VGND VGND VPWR VPWR _0603_ sky130_fd_sc_hd__mux2_1
X_2024_ clknet_leaf_15_clk _0164_ VGND VGND VPWR VPWR net89 sky130_fd_sc_hd__dfxtp_1
XFILLER_0_9_314 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_17_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold287 data\[0\]\[45\] VGND VGND VPWR VPWR net438 sky130_fd_sc_hd__dlygate4sd3_1
X_1808_ net368 _0370_ _0736_ VGND VGND VPWR VPWR _0744_ sky130_fd_sc_hd__mux2_1
Xhold265 data\[3\]\[23\] VGND VGND VPWR VPWR net416 sky130_fd_sc_hd__dlygate4sd3_1
Xhold254 data\[2\]\[24\] VGND VGND VPWR VPWR net405 sky130_fd_sc_hd__dlygate4sd3_1
Xhold276 data\[1\]\[51\] VGND VGND VPWR VPWR net427 sky130_fd_sc_hd__dlygate4sd3_1
Xhold232 data\[3\]\[57\] VGND VGND VPWR VPWR net383 sky130_fd_sc_hd__dlygate4sd3_1
Xhold221 data\[0\]\[17\] VGND VGND VPWR VPWR net372 sky130_fd_sc_hd__dlygate4sd3_1
Xhold210 data\[0\]\[61\] VGND VGND VPWR VPWR net361 sky130_fd_sc_hd__dlygate4sd3_1
X_1739_ net159 _0828_ _0703_ VGND VGND VPWR VPWR _0708_ sky130_fd_sc_hd__mux2_1
Xhold243 data\[2\]\[13\] VGND VGND VPWR VPWR net394 sky130_fd_sc_hd__dlygate4sd3_1
Xhold298 data\[0\]\[15\] VGND VGND VPWR VPWR net449 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_36_370 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_11_18 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_0972_ net2 VGND VGND VPWR VPWR _0805_ sky130_fd_sc_hd__clkbuf_4
X_1524_ net470 _0403_ _0586_ VGND VGND VPWR VPWR _0594_ sky130_fd_sc_hd__mux2_1
XFILLER_0_14_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1455_ net486 _0861_ _0553_ VGND VGND VPWR VPWR _0558_ sky130_fd_sc_hd__mux2_1
X_1386_ net400 _0425_ _0518_ VGND VGND VPWR VPWR _0522_ sky130_fd_sc_hd__mux2_1
X_2007_ clknet_leaf_17_clk _0147_ VGND VGND VPWR VPWR net110 sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_33_351 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_5_361 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_9_199 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_60_289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_13_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_36_253 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_36_231 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_51_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_51_267 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_47_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_47_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1171_ _0389_ VGND VGND VPWR VPWR _0052_ sky130_fd_sc_hd__clkbuf_1
X_1240_ data\[0\]\[69\] data\[1\]\[69\] data\[2\]\[69\] data\[3\]\[69\] _0797_ _0805_
+ VGND VGND VPWR VPWR _0442_ sky130_fd_sc_hd__mux4_1
XFILLER_0_63_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_47_443 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_2_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_30_332 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_27_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_6_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_12_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_0955_ net48 _0791_ _0775_ VGND VGND VPWR VPWR _0792_ sky130_fd_sc_hd__mux2_1
Xoutput101 net101 VGND VGND VPWR VPWR rdata[31] sky130_fd_sc_hd__clkbuf_4
Xoutput112 net112 VGND VGND VPWR VPWR rdata[41] sky130_fd_sc_hd__clkbuf_4
X_1507_ net120 _0376_ _0575_ VGND VGND VPWR VPWR _0585_ sky130_fd_sc_hd__mux2_1
Xoutput123 net123 VGND VGND VPWR VPWR rdata[51] sky130_fd_sc_hd__clkbuf_4
Xoutput145 net145 VGND VGND VPWR VPWR rdata[71] sky130_fd_sc_hd__clkbuf_4
Xoutput134 net134 VGND VGND VPWR VPWR rdata[61] sky130_fd_sc_hd__clkbuf_4
X_1369_ net404 _0397_ _0507_ VGND VGND VPWR VPWR _0513_ sky130_fd_sc_hd__mux2_1
X_1438_ net476 _0834_ _0542_ VGND VGND VPWR VPWR _0549_ sky130_fd_sc_hd__mux2_1
XFILLER_0_33_234 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_5_180 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_56_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_44_424 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xinput25 wdata[29] VGND VGND VPWR VPWR net25 sky130_fd_sc_hd__clkbuf_1
Xinput36 wdata[39] VGND VGND VPWR VPWR net36 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_56_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xinput14 wdata[19] VGND VGND VPWR VPWR net14 sky130_fd_sc_hd__clkbuf_1
Xinput47 wdata[49] VGND VGND VPWR VPWR net47 sky130_fd_sc_hd__buf_1
Xinput69 wdata[69] VGND VGND VPWR VPWR net69 sky130_fd_sc_hd__clkbuf_1
Xinput58 wdata[59] VGND VGND VPWR VPWR net58 sky130_fd_sc_hd__buf_1
X_1154_ data\[0\]\[49\] data\[1\]\[49\] data\[2\]\[49\] data\[3\]\[49\] _0365_ _0372_
+ VGND VGND VPWR VPWR _0376_ sky130_fd_sc_hd__mux4_1
X_1223_ _0429_ VGND VGND VPWR VPWR _0064_ sky130_fd_sc_hd__clkbuf_1
X_1085_ net30 _0892_ _0882_ VGND VGND VPWR VPWR _0893_ sky130_fd_sc_hd__mux2_1
XFILLER_0_47_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_55_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1987_ clknet_leaf_4_clk _0127_ VGND VGND VPWR VPWR data\[0\]\[55\] sky130_fd_sc_hd__dfxtp_1
X_0938_ _0771_ _0778_ _0772_ VGND VGND VPWR VPWR _0779_ sky130_fd_sc_hd__nor3b_2
XTAP_TAPCELL_ROW_58_516 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_41_405 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_61_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1910_ clknet_leaf_0_clk _0050_ VGND VGND VPWR VPWR data\[2\]\[50\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_29_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1772_ net150 VGND VGND VPWR VPWR _0725_ sky130_fd_sc_hd__buf_4
X_1841_ _0761_ VGND VGND VPWR VPWR _0350_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_8_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_12_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_20_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1137_ net43 _0362_ _0916_ VGND VGND VPWR VPWR _0363_ sky130_fd_sc_hd__mux2_1
X_2186_ clknet_leaf_10_clk _0326_ VGND VGND VPWR VPWR data\[1\]\[38\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_33_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1206_ net269 _0415_ _0416_ VGND VGND VPWR VPWR _0417_ sky130_fd_sc_hd__mux2_1
XFILLER_0_62_104 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1068_ net204 _0879_ _0850_ VGND VGND VPWR VPWR _0880_ sky130_fd_sc_hd__mux2_1
XFILLER_0_7_264 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_11_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_14_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_53_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_34_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_34_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_26_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2040_ clknet_leaf_12_clk _0180_ VGND VGND VPWR VPWR net106 sky130_fd_sc_hd__dfxtp_1
Xhold3 data\[3\]\[11\] VGND VGND VPWR VPWR net154 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_44_115 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_29_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_29_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1824_ _0752_ VGND VGND VPWR VPWR _0342_ sky130_fd_sc_hd__clkbuf_1
X_1755_ _0716_ VGND VGND VPWR VPWR _0309_ sky130_fd_sc_hd__clkbuf_1
X_1686_ net246 _0419_ _0678_ VGND VGND VPWR VPWR _0680_ sky130_fd_sc_hd__mux2_1
XFILLER_0_20_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2169_ clknet_leaf_19_clk _0309_ VGND VGND VPWR VPWR data\[1\]\[21\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_0_133 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_43_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_39_390 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_41_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1540_ _0602_ VGND VGND VPWR VPWR _0208_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_22_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1471_ _0566_ VGND VGND VPWR VPWR _0175_ sky130_fd_sc_hd__clkbuf_1
X_2023_ clknet_leaf_19_clk _0163_ VGND VGND VPWR VPWR net87 sky130_fd_sc_hd__dfxtp_1
XFILLER_0_15_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1807_ _0743_ VGND VGND VPWR VPWR _0334_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_32_118 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold266 data\[1\]\[31\] VGND VGND VPWR VPWR net417 sky130_fd_sc_hd__dlygate4sd3_1
Xhold233 data\[0\]\[41\] VGND VGND VPWR VPWR net384 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_40_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xhold211 data\[1\]\[70\] VGND VGND VPWR VPWR net362 sky130_fd_sc_hd__dlygate4sd3_1
X_1669_ net341 _0391_ _0667_ VGND VGND VPWR VPWR _0671_ sky130_fd_sc_hd__mux2_1
Xhold299 data\[0\]\[24\] VGND VGND VPWR VPWR net450 sky130_fd_sc_hd__dlygate4sd3_1
Xhold255 data\[2\]\[25\] VGND VGND VPWR VPWR net406 sky130_fd_sc_hd__dlygate4sd3_1
Xhold288 data\[0\]\[51\] VGND VGND VPWR VPWR net439 sky130_fd_sc_hd__dlygate4sd3_1
Xhold200 data\[2\]\[19\] VGND VGND VPWR VPWR net351 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_25_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xhold277 data\[2\]\[59\] VGND VGND VPWR VPWR net428 sky130_fd_sc_hd__dlygate4sd3_1
Xhold244 data\[0\]\[0\] VGND VGND VPWR VPWR net395 sky130_fd_sc_hd__dlygate4sd3_1
Xhold222 data\[0\]\[69\] VGND VGND VPWR VPWR net373 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_13_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1738_ _0707_ VGND VGND VPWR VPWR _0301_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_36_371 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_52_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_52_59 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_39_284 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_39_240 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_0971_ _0804_ VGND VGND VPWR VPWR _0007_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_14_118 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1454_ _0557_ VGND VGND VPWR VPWR _0167_ sky130_fd_sc_hd__clkbuf_1
X_1523_ _0593_ VGND VGND VPWR VPWR _0200_ sky130_fd_sc_hd__clkbuf_1
X_1385_ _0521_ VGND VGND VPWR VPWR _0134_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_33_352 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_26_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2006_ clknet_leaf_24_clk _0146_ VGND VGND VPWR VPWR net99 sky130_fd_sc_hd__dfxtp_1
XFILLER_0_45_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_45_243 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_6_70 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_51_202 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_36_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_36_243 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_22_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_51_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1170_ net306 _0388_ _0382_ VGND VGND VPWR VPWR _0389_ sky130_fd_sc_hd__mux2_1
XFILLER_0_63_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_59_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_47_444 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_leaf_29_clk clknet_2_0__leaf_clk VGND VGND VPWR VPWR clknet_leaf_29_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_0_42_224 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_42_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_30_333 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_27_298 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_2_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_12_62 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0954_ data\[0\]\[4\] data\[1\]\[4\] data\[2\]\[4\] data\[3\]\[4\] _0771_ _0772_
+ VGND VGND VPWR VPWR _0791_ sky130_fd_sc_hd__mux4_1
Xoutput102 net102 VGND VGND VPWR VPWR rdata[32] sky130_fd_sc_hd__clkbuf_4
Xoutput113 net113 VGND VGND VPWR VPWR rdata[42] sky130_fd_sc_hd__clkbuf_4
X_1506_ _0584_ VGND VGND VPWR VPWR _0192_ sky130_fd_sc_hd__clkbuf_1
Xoutput124 net124 VGND VGND VPWR VPWR rdata[52] sky130_fd_sc_hd__clkbuf_4
XFILLER_0_2_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput146 net146 VGND VGND VPWR VPWR rdata[7] sky130_fd_sc_hd__clkbuf_4
Xoutput135 net135 VGND VGND VPWR VPWR rdata[62] sky130_fd_sc_hd__clkbuf_4
X_1437_ _0548_ VGND VGND VPWR VPWR _0159_ sky130_fd_sc_hd__clkbuf_1
X_1299_ _0476_ VGND VGND VPWR VPWR _0093_ sky130_fd_sc_hd__clkbuf_1
X_1368_ _0512_ VGND VGND VPWR VPWR _0126_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_53_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_18_232 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_33_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_33_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_18_298 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_17_18 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_44_425 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_52_480 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xinput37 wdata[3] VGND VGND VPWR VPWR net37 sky130_fd_sc_hd__buf_1
Xinput48 wdata[4] VGND VGND VPWR VPWR net48 sky130_fd_sc_hd__buf_1
Xinput59 wdata[5] VGND VGND VPWR VPWR net59 sky130_fd_sc_hd__clkbuf_1
Xinput15 wdata[1] VGND VGND VPWR VPWR net15 sky130_fd_sc_hd__clkbuf_1
Xinput26 wdata[2] VGND VGND VPWR VPWR net26 sky130_fd_sc_hd__clkbuf_1
X_1084_ data\[0\]\[33\] data\[1\]\[33\] data\[2\]\[33\] data\[3\]\[33\] _0867_ _0874_
+ VGND VGND VPWR VPWR _0892_ sky130_fd_sc_hd__mux4_1
X_1153_ _0375_ VGND VGND VPWR VPWR _0048_ sky130_fd_sc_hd__clkbuf_1
X_1222_ net259 _0428_ _0416_ VGND VGND VPWR VPWR _0429_ sky130_fd_sc_hd__mux2_1
XFILLER_0_55_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1986_ clknet_leaf_4_clk _0126_ VGND VGND VPWR VPWR data\[0\]\[54\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_23_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_61_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_leaf_9_clk clknet_2_1__leaf_clk VGND VGND VPWR VPWR clknet_leaf_9_clk sky130_fd_sc_hd__clkbuf_8
X_0937_ _0777_ VGND VGND VPWR VPWR _0778_ sky130_fd_sc_hd__buf_4
XFILLER_0_15_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_58_517 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_53_308 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_41_406 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_21_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_44_38 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_60_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_56_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1840_ net176 _0422_ _0758_ VGND VGND VPWR VPWR _0761_ sky130_fd_sc_hd__mux2_1
X_1771_ _0724_ VGND VGND VPWR VPWR _0317_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_52_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2185_ clknet_leaf_8_clk _0325_ VGND VGND VPWR VPWR data\[1\]\[37\] sky130_fd_sc_hd__dfxtp_1
X_1067_ net25 _0878_ _0848_ VGND VGND VPWR VPWR _0879_ sky130_fd_sc_hd__mux2_1
X_1136_ data\[0\]\[45\] data\[1\]\[45\] data\[2\]\[45\] data\[3\]\[45\] _0901_ _0908_
+ VGND VGND VPWR VPWR _0362_ sky130_fd_sc_hd__mux4_1
XFILLER_0_47_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_47_102 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_18_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1205_ net149 VGND VGND VPWR VPWR _0416_ sky130_fd_sc_hd__buf_4
XFILLER_0_62_116 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1969_ clknet_leaf_8_clk _0109_ VGND VGND VPWR VPWR data\[0\]\[37\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_47_124 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_43_374 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_38_168 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_30_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_55_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold4 data\[1\]\[20\] VGND VGND VPWR VPWR net155 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_55_48 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1823_ net201 _0394_ _0747_ VGND VGND VPWR VPWR _0752_ sky130_fd_sc_hd__mux2_1
XFILLER_0_29_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1754_ net289 _0853_ _0714_ VGND VGND VPWR VPWR _0716_ sky130_fd_sc_hd__mux2_1
XFILLER_0_25_374 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1685_ _0679_ VGND VGND VPWR VPWR _0276_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_29_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1119_ _0919_ VGND VGND VPWR VPWR _0040_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_45_92 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2099_ clknet_leaf_16_clk _0239_ VGND VGND VPWR VPWR data\[3\]\[23\] sky130_fd_sc_hd__dfxtp_1
X_2168_ clknet_leaf_15_clk _0308_ VGND VGND VPWR VPWR data\[1\]\[20\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_0_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_0_134 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_43_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_31_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_16_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_17_Right_17 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_26_Right_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_39_391 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_41_28 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_35_Right_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_26_116 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1470_ net447 _0886_ _0564_ VGND VGND VPWR VPWR _0566_ sky130_fd_sc_hd__mux2_1
XFILLER_0_1_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_22_280 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_44_Right_44 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_53_Right_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2022_ clknet_leaf_19_clk _0162_ VGND VGND VPWR VPWR net86 sky130_fd_sc_hd__dfxtp_1
XFILLER_0_15_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_15_95 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1806_ net344 _0367_ _0736_ VGND VGND VPWR VPWR _0743_ sky130_fd_sc_hd__mux2_1
Xhold201 data\[1\]\[15\] VGND VGND VPWR VPWR net352 sky130_fd_sc_hd__dlygate4sd3_1
XPHY_EDGE_ROW_62_Right_62 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold223 data\[0\]\[33\] VGND VGND VPWR VPWR net374 sky130_fd_sc_hd__dlygate4sd3_1
Xhold256 data\[1\]\[27\] VGND VGND VPWR VPWR net407 sky130_fd_sc_hd__dlygate4sd3_1
Xhold289 net96 VGND VGND VPWR VPWR net440 sky130_fd_sc_hd__dlygate4sd3_1
Xhold212 data\[0\]\[49\] VGND VGND VPWR VPWR net363 sky130_fd_sc_hd__dlygate4sd3_1
X_1599_ _0611_ VGND VGND VPWR VPWR _0634_ sky130_fd_sc_hd__buf_4
X_1668_ _0670_ VGND VGND VPWR VPWR _0268_ sky130_fd_sc_hd__clkbuf_1
XPHY_EDGE_ROW_37_Left_102 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold234 data\[1\]\[19\] VGND VGND VPWR VPWR net385 sky130_fd_sc_hd__dlygate4sd3_1
Xhold267 data\[1\]\[25\] VGND VGND VPWR VPWR net418 sky130_fd_sc_hd__dlygate4sd3_1
Xhold278 data\[2\]\[0\] VGND VGND VPWR VPWR net429 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_0_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xhold245 data\[1\]\[10\] VGND VGND VPWR VPWR net396 sky130_fd_sc_hd__dlygate4sd3_1
X_1737_ net205 _0825_ _0703_ VGND VGND VPWR VPWR _0707_ sky130_fd_sc_hd__mux2_1
XPHY_EDGE_ROW_46_Left_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_36_372 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_55_Left_120 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_31_152 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_0970_ net364 _0803_ _0780_ VGND VGND VPWR VPWR _0804_ sky130_fd_sc_hd__mux2_1
X_1453_ net501 _0858_ _0553_ VGND VGND VPWR VPWR _0557_ sky130_fd_sc_hd__mux2_1
X_1522_ net471 _0400_ _0586_ VGND VGND VPWR VPWR _0593_ sky130_fd_sc_hd__mux2_1
XFILLER_0_26_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1384_ net319 _0422_ _0518_ VGND VGND VPWR VPWR _0521_ sky130_fd_sc_hd__mux2_1
X_2005_ clknet_leaf_23_clk _0145_ VGND VGND VPWR VPWR net88 sky130_fd_sc_hd__dfxtp_1
XFILLER_0_45_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_33_353 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_9_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_60_236 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_13_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_51_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_63_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_47_445 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_2_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xoutput103 net103 VGND VGND VPWR VPWR rdata[33] sky130_fd_sc_hd__clkbuf_4
Xoutput125 net125 VGND VGND VPWR VPWR rdata[53] sky130_fd_sc_hd__clkbuf_4
Xoutput114 net114 VGND VGND VPWR VPWR rdata[43] sky130_fd_sc_hd__clkbuf_4
XTAP_TAPCELL_ROW_30_334 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_0953_ _0790_ VGND VGND VPWR VPWR _0003_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_2_333 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_12_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1505_ net480 _0373_ _0575_ VGND VGND VPWR VPWR _0584_ sky130_fd_sc_hd__mux2_1
X_1367_ net277 _0394_ _0507_ VGND VGND VPWR VPWR _0512_ sky130_fd_sc_hd__mux2_1
XFILLER_0_2_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xoutput147 net147 VGND VGND VPWR VPWR rdata[8] sky130_fd_sc_hd__clkbuf_4
Xoutput136 net136 VGND VGND VPWR VPWR rdata[63] sky130_fd_sc_hd__clkbuf_4
X_1436_ net441 _0830_ _0542_ VGND VGND VPWR VPWR _0548_ sky130_fd_sc_hd__mux2_1
X_1298_ net430 _0853_ _0474_ VGND VGND VPWR VPWR _0476_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_44_426 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_64_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xinput27 wdata[30] VGND VGND VPWR VPWR net27 sky130_fd_sc_hd__buf_1
Xinput38 wdata[40] VGND VGND VPWR VPWR net38 sky130_fd_sc_hd__clkbuf_1
Xinput16 wdata[20] VGND VGND VPWR VPWR net16 sky130_fd_sc_hd__clkbuf_1
Xinput49 wdata[50] VGND VGND VPWR VPWR net49 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_24_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_58_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1221_ net64 _0427_ _0414_ VGND VGND VPWR VPWR _0428_ sky130_fd_sc_hd__mux2_1
X_1083_ _0891_ VGND VGND VPWR VPWR _0032_ sky130_fd_sc_hd__clkbuf_1
X_1152_ net313 _0374_ _0918_ VGND VGND VPWR VPWR _0375_ sky130_fd_sc_hd__mux2_1
XFILLER_0_62_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1985_ clknet_leaf_2_clk _0125_ VGND VGND VPWR VPWR data\[0\]\[53\] sky130_fd_sc_hd__dfxtp_1
X_0936_ _0774_ net76 VGND VGND VPWR VPWR _0777_ sky130_fd_sc_hd__nor2b_2
XTAP_TAPCELL_ROW_58_518 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_48_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1419_ net386 _0802_ _0531_ VGND VGND VPWR VPWR _0539_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_41_407 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_60_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_56_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1770_ net156 _0879_ _0714_ VGND VGND VPWR VPWR _0724_ sky130_fd_sc_hd__mux2_1
X_2184_ clknet_leaf_8_clk _0324_ VGND VGND VPWR VPWR data\[1\]\[36\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_40_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1204_ net60 _0413_ _0414_ VGND VGND VPWR VPWR _0415_ sky130_fd_sc_hd__mux2_1
X_1135_ _0361_ VGND VGND VPWR VPWR _0044_ sky130_fd_sc_hd__clkbuf_1
X_1066_ data\[0\]\[29\] data\[1\]\[29\] data\[2\]\[29\] data\[3\]\[29\] _0867_ _0874_
+ VGND VGND VPWR VPWR _0878_ sky130_fd_sc_hd__mux4_1
XFILLER_0_19_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1968_ clknet_leaf_8_clk _0108_ VGND VGND VPWR VPWR data\[0\]\[36\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_50_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1899_ clknet_leaf_9_clk _0039_ VGND VGND VPWR VPWR data\[2\]\[39\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_7_288 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_11_250 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_38_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_19_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold5 data\[1\]\[29\] VGND VGND VPWR VPWR net156 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_55_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_44_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1822_ _0751_ VGND VGND VPWR VPWR _0341_ sky130_fd_sc_hd__clkbuf_1
X_1753_ _0715_ VGND VGND VPWR VPWR _0308_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_29_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_29_Left_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_4_236 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1684_ net163 _0415_ _0678_ VGND VGND VPWR VPWR _0679_ sky130_fd_sc_hd__mux2_1
X_2167_ clknet_leaf_19_clk _0307_ VGND VGND VPWR VPWR data\[1\]\[19\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_0_135 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_13_Left_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1118_ net358 _0917_ _0918_ VGND VGND VPWR VPWR _0919_ sky130_fd_sc_hd__mux2_1
X_2098_ clknet_leaf_14_clk _0238_ VGND VGND VPWR VPWR data\[3\]\[22\] sky130_fd_sc_hd__dfxtp_1
X_1049_ net21 _0864_ _0848_ VGND VGND VPWR VPWR _0865_ sky130_fd_sc_hd__mux2_1
XFILLER_0_0_62 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_31_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_28_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_39_392 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_22_281 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2021_ clknet_leaf_18_clk _0161_ VGND VGND VPWR VPWR net85 sky130_fd_sc_hd__dfxtp_1
XFILLER_0_57_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1805_ _0742_ VGND VGND VPWR VPWR _0333_ sky130_fd_sc_hd__clkbuf_1
Xhold224 data\[2\]\[23\] VGND VGND VPWR VPWR net375 sky130_fd_sc_hd__dlygate4sd3_1
X_1736_ _0706_ VGND VGND VPWR VPWR _0300_ sky130_fd_sc_hd__clkbuf_1
Xhold235 net146 VGND VGND VPWR VPWR net386 sky130_fd_sc_hd__dlygate4sd3_1
Xhold213 data\[2\]\[7\] VGND VGND VPWR VPWR net364 sky130_fd_sc_hd__dlygate4sd3_1
Xhold202 data\[0\]\[5\] VGND VGND VPWR VPWR net353 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_13_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xhold257 data\[2\]\[39\] VGND VGND VPWR VPWR net408 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_40_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1667_ net167 _0388_ _0667_ VGND VGND VPWR VPWR _0670_ sky130_fd_sc_hd__mux2_1
Xhold279 data\[0\]\[21\] VGND VGND VPWR VPWR net430 sky130_fd_sc_hd__dlygate4sd3_1
X_1598_ _0633_ VGND VGND VPWR VPWR _0235_ sky130_fd_sc_hd__clkbuf_1
Xhold246 data\[0\]\[10\] VGND VGND VPWR VPWR net397 sky130_fd_sc_hd__dlygate4sd3_1
Xhold268 data\[1\]\[65\] VGND VGND VPWR VPWR net419 sky130_fd_sc_hd__dlygate4sd3_1
X_2219_ clknet_leaf_17_clk _0359_ VGND VGND VPWR VPWR data\[1\]\[71\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_28_318 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_48_264 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_36_373 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_6_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_6_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1452_ _0556_ VGND VGND VPWR VPWR _0166_ sky130_fd_sc_hd__clkbuf_1
X_1521_ _0592_ VGND VGND VPWR VPWR _0199_ sky130_fd_sc_hd__clkbuf_1
X_1383_ _0520_ VGND VGND VPWR VPWR _0133_ sky130_fd_sc_hd__clkbuf_1
X_2004_ clknet_leaf_23_clk _0144_ VGND VGND VPWR VPWR net77 sky130_fd_sc_hd__dfxtp_1
XFILLER_0_42_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_33_354 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_9_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_9_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_60_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1719_ _0697_ VGND VGND VPWR VPWR _0292_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_13_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_16_Left_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_8_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_63_27 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_59_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_47_446 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_30_335 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_6_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_12_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_0952_ net265 _0789_ _0780_ VGND VGND VPWR VPWR _0790_ sky130_fd_sc_hd__mux2_1
Xoutput115 net115 VGND VGND VPWR VPWR rdata[44] sky130_fd_sc_hd__clkbuf_4
XFILLER_0_50_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xoutput126 net126 VGND VGND VPWR VPWR rdata[54] sky130_fd_sc_hd__clkbuf_4
X_1504_ _0583_ VGND VGND VPWR VPWR _0191_ sky130_fd_sc_hd__clkbuf_1
Xoutput104 net104 VGND VGND VPWR VPWR rdata[34] sky130_fd_sc_hd__clkbuf_4
XFILLER_0_2_345 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput137 net137 VGND VGND VPWR VPWR rdata[64] sky130_fd_sc_hd__clkbuf_4
Xoutput148 net148 VGND VGND VPWR VPWR rdata[9] sky130_fd_sc_hd__clkbuf_4
X_1366_ _0511_ VGND VGND VPWR VPWR _0125_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_10_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1435_ _0547_ VGND VGND VPWR VPWR _0158_ sky130_fd_sc_hd__clkbuf_1
X_1297_ _0475_ VGND VGND VPWR VPWR _0092_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_41_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_44_427 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_1_Left_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xinput39 wdata[41] VGND VGND VPWR VPWR net39 sky130_fd_sc_hd__clkbuf_1
Xinput28 wdata[31] VGND VGND VPWR VPWR net28 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_58_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xinput17 wdata[21] VGND VGND VPWR VPWR net17 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_32_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1151_ net46 _0373_ _0916_ VGND VGND VPWR VPWR _0374_ sky130_fd_sc_hd__mux2_1
X_1220_ data\[0\]\[64\] data\[1\]\[64\] data\[2\]\[64\] data\[3\]\[64\] _0399_ _0406_
+ VGND VGND VPWR VPWR _0427_ sky130_fd_sc_hd__mux4_1
XFILLER_0_59_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1082_ net302 _0890_ _0884_ VGND VGND VPWR VPWR _0891_ sky130_fd_sc_hd__mux2_1
XFILLER_0_47_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_23_30 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1984_ clknet_leaf_3_clk _0124_ VGND VGND VPWR VPWR data\[0\]\[52\] sky130_fd_sc_hd__dfxtp_1
X_0935_ net4 _0773_ _0775_ VGND VGND VPWR VPWR _0776_ sky130_fd_sc_hd__mux2_1
XFILLER_0_23_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_2_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_23_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_58_519 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1349_ _0502_ VGND VGND VPWR VPWR _0117_ sky130_fd_sc_hd__clkbuf_1
X_1418_ _0538_ VGND VGND VPWR VPWR _0150_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_3_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_3_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_41_408 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_46_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_14_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_44_18 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_8_18 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_8_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_52_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_20_262 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2183_ clknet_leaf_12_clk _0323_ VGND VGND VPWR VPWR data\[1\]\[35\] sky130_fd_sc_hd__dfxtp_1
X_1134_ net238 _0360_ _0918_ VGND VGND VPWR VPWR _0361_ sky130_fd_sc_hd__mux2_1
XFILLER_0_18_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1203_ _0774_ VGND VGND VPWR VPWR _0414_ sky130_fd_sc_hd__buf_4
X_1065_ _0877_ VGND VGND VPWR VPWR _0028_ sky130_fd_sc_hd__clkbuf_1
X_1967_ clknet_leaf_12_clk _0107_ VGND VGND VPWR VPWR data\[0\]\[35\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_50_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1898_ clknet_leaf_9_clk _0038_ VGND VGND VPWR VPWR data\[2\]\[38\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_7_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_11_262 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_38_115 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_61_140 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_55_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold6 data\[0\]\[20\] VGND VGND VPWR VPWR net157 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_52_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1752_ net155 _0849_ _0714_ VGND VGND VPWR VPWR _0715_ sky130_fd_sc_hd__mux2_1
Xclkbuf_leaf_10_clk clknet_2_3__leaf_clk VGND VGND VPWR VPWR clknet_leaf_10_clk sky130_fd_sc_hd__clkbuf_8
X_1821_ net409 _0391_ _0747_ VGND VGND VPWR VPWR _0751_ sky130_fd_sc_hd__mux2_1
XFILLER_0_20_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1683_ _0611_ VGND VGND VPWR VPWR _0678_ sky130_fd_sc_hd__buf_4
X_1117_ net149 VGND VGND VPWR VPWR _0918_ sky130_fd_sc_hd__buf_4
X_2097_ clknet_leaf_15_clk _0237_ VGND VGND VPWR VPWR data\[3\]\[21\] sky130_fd_sc_hd__dfxtp_1
X_2166_ clknet_leaf_19_clk _0306_ VGND VGND VPWR VPWR data\[1\]\[18\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_0_136 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1048_ data\[0\]\[25\] data\[1\]\[25\] data\[2\]\[25\] data\[3\]\[25\] _0833_ _0840_
+ VGND VGND VPWR VPWR _0864_ sky130_fd_sc_hd__mux4_1
XFILLER_0_35_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_3_Right_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_0_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_16_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_31_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_3_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_16_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_39_393 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_227 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_34_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_30_Left_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_22_282 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2020_ clknet_leaf_17_clk _0160_ VGND VGND VPWR VPWR net84 sky130_fd_sc_hd__dfxtp_1
Xhold203 data\[0\]\[26\] VGND VGND VPWR VPWR net354 sky130_fd_sc_hd__dlygate4sd3_1
X_1804_ net152 _0363_ _0736_ VGND VGND VPWR VPWR _0742_ sky130_fd_sc_hd__mux2_1
Xhold214 data\[1\]\[22\] VGND VGND VPWR VPWR net365 sky130_fd_sc_hd__dlygate4sd3_1
Xhold225 data\[3\]\[48\] VGND VGND VPWR VPWR net376 sky130_fd_sc_hd__dlygate4sd3_1
Xhold269 data\[2\]\[20\] VGND VGND VPWR VPWR net420 sky130_fd_sc_hd__dlygate4sd3_1
Xhold258 data\[1\]\[53\] VGND VGND VPWR VPWR net409 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_31_63 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold247 data\[3\]\[56\] VGND VGND VPWR VPWR net398 sky130_fd_sc_hd__dlygate4sd3_1
X_1666_ _0669_ VGND VGND VPWR VPWR _0267_ sky130_fd_sc_hd__clkbuf_1
Xhold236 data\[3\]\[58\] VGND VGND VPWR VPWR net387 sky130_fd_sc_hd__dlygate4sd3_1
X_1735_ net202 _0822_ _0703_ VGND VGND VPWR VPWR _0706_ sky130_fd_sc_hd__mux2_1
X_1597_ net239 _0845_ _0623_ VGND VGND VPWR VPWR _0633_ sky130_fd_sc_hd__mux2_1
XFILLER_0_48_232 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_36_374 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2218_ clknet_leaf_10_clk _0358_ VGND VGND VPWR VPWR data\[1\]\[70\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_28_319 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2149_ clknet_leaf_27_clk _0289_ VGND VGND VPWR VPWR data\[1\]\[1\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_11_208 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1520_ net472 _0396_ _0586_ VGND VGND VPWR VPWR _0592_ sky130_fd_sc_hd__mux2_1
X_1451_ net425 _0855_ _0553_ VGND VGND VPWR VPWR _0556_ sky130_fd_sc_hd__mux2_1
X_1382_ net361 _0419_ _0518_ VGND VGND VPWR VPWR _0520_ sky130_fd_sc_hd__mux2_1
X_2003_ clknet_leaf_17_clk _0143_ VGND VGND VPWR VPWR data\[0\]\[71\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_26_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_45_202 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_33_355 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1649_ _0660_ VGND VGND VPWR VPWR _0259_ sky130_fd_sc_hd__clkbuf_1
X_1718_ net220 _0792_ _0692_ VGND VGND VPWR VPWR _0697_ sky130_fd_sc_hd__mux2_1
XFILLER_0_47_18 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_63_39 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_59_349 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_59_305 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_47_447 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_30_336 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_27_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_27_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_0951_ net37 _0788_ _0775_ VGND VGND VPWR VPWR _0789_ sky130_fd_sc_hd__mux2_1
Xoutput105 net105 VGND VGND VPWR VPWR rdata[35] sky130_fd_sc_hd__clkbuf_4
Xoutput116 net116 VGND VGND VPWR VPWR rdata[45] sky130_fd_sc_hd__clkbuf_4
X_1503_ net479 _0369_ _0575_ VGND VGND VPWR VPWR _0583_ sky130_fd_sc_hd__mux2_1
XFILLER_0_42_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xoutput127 net127 VGND VGND VPWR VPWR rdata[55] sky130_fd_sc_hd__clkbuf_4
XFILLER_0_2_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_10_157 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput138 net138 VGND VGND VPWR VPWR rdata[65] sky130_fd_sc_hd__clkbuf_4
X_1296_ net157 _0849_ _0474_ VGND VGND VPWR VPWR _0475_ sky130_fd_sc_hd__mux2_1
X_1365_ net435 _0391_ _0507_ VGND VGND VPWR VPWR _0511_ sky130_fd_sc_hd__mux2_1
XFILLER_0_37_73 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1434_ net388 _0827_ _0542_ VGND VGND VPWR VPWR _0547_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_44_428 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xinput18 wdata[22] VGND VGND VPWR VPWR net18 sky130_fd_sc_hd__clkbuf_1
Xinput29 wdata[32] VGND VGND VPWR VPWR net29 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_32_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_17_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1150_ data\[0\]\[48\] data\[1\]\[48\] data\[2\]\[48\] data\[3\]\[48\] _0365_ _0372_
+ VGND VGND VPWR VPWR _0373_ sky130_fd_sc_hd__mux4_1
X_1081_ net29 _0889_ _0882_ VGND VGND VPWR VPWR _0890_ sky130_fd_sc_hd__mux2_1
XFILLER_0_23_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1983_ clknet_leaf_2_clk _0123_ VGND VGND VPWR VPWR data\[0\]\[51\] sky130_fd_sc_hd__dfxtp_1
X_0934_ _0774_ VGND VGND VPWR VPWR _0775_ sky130_fd_sc_hd__buf_4
XFILLER_0_2_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1417_ net336 _0799_ _0531_ VGND VGND VPWR VPWR _0538_ sky130_fd_sc_hd__mux2_1
XFILLER_0_64_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1348_ net438 _0363_ _0496_ VGND VGND VPWR VPWR _0502_ sky130_fd_sc_hd__mux2_1
XFILLER_0_3_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1279_ net231 _0822_ _0463_ VGND VGND VPWR VPWR _0466_ sky130_fd_sc_hd__mux2_1
XFILLER_0_46_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_14_282 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_6_175 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_60_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1133_ net42 _0929_ _0916_ VGND VGND VPWR VPWR _0360_ sky130_fd_sc_hd__mux2_1
X_1064_ net184 _0876_ _0850_ VGND VGND VPWR VPWR _0877_ sky130_fd_sc_hd__mux2_1
X_2182_ clknet_leaf_10_clk _0322_ VGND VGND VPWR VPWR data\[1\]\[34\] sky130_fd_sc_hd__dfxtp_1
X_1202_ data\[0\]\[60\] data\[1\]\[60\] data\[2\]\[60\] data\[3\]\[60\] _0399_ _0406_
+ VGND VGND VPWR VPWR _0413_ sky130_fd_sc_hd__mux4_1
XFILLER_0_47_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1966_ clknet_leaf_16_clk _0106_ VGND VGND VPWR VPWR data\[0\]\[34\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_28_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1897_ clknet_leaf_8_clk _0037_ VGND VGND VPWR VPWR data\[2\]\[37\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_43_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_3_156 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_34_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_61_196 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xhold7 data\[3\]\[64\] VGND VGND VPWR VPWR net158 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_60_526 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1820_ _0750_ VGND VGND VPWR VPWR _0340_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_17_247 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_52_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1751_ net150 VGND VGND VPWR VPWR _0714_ sky130_fd_sc_hd__buf_4
X_1682_ _0677_ VGND VGND VPWR VPWR _0275_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_29_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1116_ net38 _0915_ _0916_ VGND VGND VPWR VPWR _0917_ sky130_fd_sc_hd__mux2_1
X_2096_ clknet_leaf_15_clk _0236_ VGND VGND VPWR VPWR data\[3\]\[20\] sky130_fd_sc_hd__dfxtp_1
X_1047_ _0863_ VGND VGND VPWR VPWR _0024_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_0_137 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2165_ clknet_leaf_18_clk _0305_ VGND VGND VPWR VPWR data\[1\]\[17\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_0_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1949_ clknet_leaf_18_clk _0089_ VGND VGND VPWR VPWR data\[0\]\[17\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_3_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_39_394 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_26_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_14_228 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_34_152 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_22_283 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_13_Right_13 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1803_ _0741_ VGND VGND VPWR VPWR _0332_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_57_299 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_57_244 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_22_Right_22 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold248 data\[0\]\[35\] VGND VGND VPWR VPWR net399 sky130_fd_sc_hd__dlygate4sd3_1
Xhold259 data\[0\]\[23\] VGND VGND VPWR VPWR net410 sky130_fd_sc_hd__dlygate4sd3_1
Xhold204 data\[1\]\[38\] VGND VGND VPWR VPWR net355 sky130_fd_sc_hd__dlygate4sd3_1
Xhold215 data\[0\]\[70\] VGND VGND VPWR VPWR net366 sky130_fd_sc_hd__dlygate4sd3_1
X_1665_ net415 _0385_ _0667_ VGND VGND VPWR VPWR _0669_ sky130_fd_sc_hd__mux2_1
X_1596_ _0632_ VGND VGND VPWR VPWR _0234_ sky130_fd_sc_hd__clkbuf_1
X_1734_ _0705_ VGND VGND VPWR VPWR _0299_ sky130_fd_sc_hd__clkbuf_1
Xhold237 net82 VGND VGND VPWR VPWR net388 sky130_fd_sc_hd__dlygate4sd3_1
Xhold226 data\[0\]\[65\] VGND VGND VPWR VPWR net377 sky130_fd_sc_hd__dlygate4sd3_1
XPHY_EDGE_ROW_31_Right_31 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2217_ clknet_leaf_28_clk _0357_ VGND VGND VPWR VPWR data\[1\]\[69\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_48_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_36_375 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2079_ clknet_leaf_25_clk _0219_ VGND VGND VPWR VPWR data\[3\]\[3\] sky130_fd_sc_hd__dfxtp_1
X_2148_ clknet_leaf_27_clk _0288_ VGND VGND VPWR VPWR data\[1\]\[0\] sky130_fd_sc_hd__dfxtp_1
XPHY_EDGE_ROW_40_Right_40 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_31_122 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_11_209 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_16_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_39_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1450_ _0555_ VGND VGND VPWR VPWR _0165_ sky130_fd_sc_hd__clkbuf_1
X_1381_ _0519_ VGND VGND VPWR VPWR _0132_ sky130_fd_sc_hd__clkbuf_1
X_2002_ clknet_leaf_25_clk _0142_ VGND VGND VPWR VPWR data\[0\]\[70\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_42_96 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_33_356 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_13_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1648_ net180 _0927_ _0656_ VGND VGND VPWR VPWR _0660_ sky130_fd_sc_hd__mux2_1
X_1717_ _0696_ VGND VGND VPWR VPWR _0291_ sky130_fd_sc_hd__clkbuf_1
X_1579_ net199 _0815_ _0623_ VGND VGND VPWR VPWR _0624_ sky130_fd_sc_hd__mux2_1
XFILLER_0_59_317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_30_337 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_0950_ data\[0\]\[3\] data\[1\]\[3\] data\[2\]\[3\] data\[3\]\[3\] _0771_ _0772_
+ VGND VGND VPWR VPWR _0788_ sky130_fd_sc_hd__mux4_1
XFILLER_0_2_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xoutput106 net106 VGND VGND VPWR VPWR rdata[36] sky130_fd_sc_hd__clkbuf_4
Xoutput117 net117 VGND VGND VPWR VPWR rdata[46] sky130_fd_sc_hd__clkbuf_4
X_1502_ _0582_ VGND VGND VPWR VPWR _0190_ sky130_fd_sc_hd__clkbuf_1
Xoutput128 net128 VGND VGND VPWR VPWR rdata[56] sky130_fd_sc_hd__clkbuf_4
X_1433_ _0546_ VGND VGND VPWR VPWR _0157_ sky130_fd_sc_hd__clkbuf_1
Xoutput139 net139 VGND VGND VPWR VPWR rdata[66] sky130_fd_sc_hd__clkbuf_4
X_1364_ _0510_ VGND VGND VPWR VPWR _0124_ sky130_fd_sc_hd__clkbuf_1
X_1295_ net151 VGND VGND VPWR VPWR _0474_ sky130_fd_sc_hd__buf_4
XFILLER_0_37_85 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_18_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_5_196 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_5_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_56_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xinput19 wdata[23] VGND VGND VPWR VPWR net19 sky130_fd_sc_hd__clkbuf_1
X_1080_ data\[0\]\[32\] data\[1\]\[32\] data\[2\]\[32\] data\[3\]\[32\] _0867_ _0874_
+ VGND VGND VPWR VPWR _0889_ sky130_fd_sc_hd__mux4_1
XTAP_TAPCELL_ROW_9_195 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_59_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1982_ clknet_leaf_2_clk _0122_ VGND VGND VPWR VPWR data\[0\]\[50\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_23_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_0933_ net3 VGND VGND VPWR VPWR _0774_ sky130_fd_sc_hd__buf_4
X_1347_ _0501_ VGND VGND VPWR VPWR _0116_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_54_6 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1416_ _0537_ VGND VGND VPWR VPWR _0149_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_23_294 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1278_ _0465_ VGND VGND VPWR VPWR _0083_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_57_510 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_6_176 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_52_378 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_52_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_37_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_20_286 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1201_ _0412_ VGND VGND VPWR VPWR _0059_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_63_546 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1132_ data\[0\]\[44\] data\[1\]\[44\] data\[2\]\[44\] data\[3\]\[44\] _0901_ _0908_
+ VGND VGND VPWR VPWR _0929_ sky130_fd_sc_hd__mux4_1
X_2181_ clknet_leaf_11_clk _0321_ VGND VGND VPWR VPWR data\[1\]\[33\] sky130_fd_sc_hd__dfxtp_1
X_1063_ net24 _0875_ _0848_ VGND VGND VPWR VPWR _0876_ sky130_fd_sc_hd__mux2_1
X_1965_ clknet_leaf_11_clk _0105_ VGND VGND VPWR VPWR data\[0\]\[33\] sky130_fd_sc_hd__dfxtp_1
X_1896_ clknet_leaf_9_clk _0036_ VGND VGND VPWR VPWR data\[2\]\[36\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_52_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_3_157 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_19_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_61_175 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_46_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_46_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xhold8 data\[1\]\[14\] VGND VGND VPWR VPWR net159 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_60_527 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1750_ _0713_ VGND VGND VPWR VPWR _0307_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_25_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_4_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_17_248 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_52_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_40_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xmax_cap149 _0779_ VGND VGND VPWR VPWR net149 sky130_fd_sc_hd__buf_2
X_1681_ net213 _0411_ _0667_ VGND VGND VPWR VPWR _0677_ sky130_fd_sc_hd__mux2_1
XFILLER_0_20_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2164_ clknet_leaf_17_clk _0304_ VGND VGND VPWR VPWR data\[1\]\[16\] sky130_fd_sc_hd__dfxtp_1
X_1115_ _0774_ VGND VGND VPWR VPWR _0916_ sky130_fd_sc_hd__buf_4
X_1046_ net405 _0862_ _0850_ VGND VGND VPWR VPWR _0863_ sky130_fd_sc_hd__mux2_1
X_2095_ clknet_leaf_19_clk _0235_ VGND VGND VPWR VPWR data\[3\]\[19\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_0_138 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_17_6 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1879_ clknet_leaf_19_clk _0019_ VGND VGND VPWR VPWR data\[2\]\[19\] sky130_fd_sc_hd__dfxtp_1
X_1948_ clknet_leaf_18_clk _0088_ VGND VGND VPWR VPWR data\[0\]\[16\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_0_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_9_30 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_39_395 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_14_229 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_22_284 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_2_3__f_clk clknet_0_clk VGND VGND VPWR VPWR clknet_2_3__leaf_clk sky130_fd_sc_hd__clkbuf_16
X_1802_ net208 _0360_ _0736_ VGND VGND VPWR VPWR _0741_ sky130_fd_sc_hd__mux2_1
XFILLER_0_57_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1733_ net153 _0819_ _0703_ VGND VGND VPWR VPWR _0705_ sky130_fd_sc_hd__mux2_1
Xhold238 data\[0\]\[46\] VGND VGND VPWR VPWR net389 sky130_fd_sc_hd__dlygate4sd3_1
X_1664_ _0668_ VGND VGND VPWR VPWR _0266_ sky130_fd_sc_hd__clkbuf_1
X_1595_ net210 _0842_ _0623_ VGND VGND VPWR VPWR _0632_ sky130_fd_sc_hd__mux2_1
XFILLER_0_0_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xhold205 data\[2\]\[66\] VGND VGND VPWR VPWR net356 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_13_348 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xhold249 data\[0\]\[63\] VGND VGND VPWR VPWR net400 sky130_fd_sc_hd__dlygate4sd3_1
Xhold216 data\[2\]\[15\] VGND VGND VPWR VPWR net367 sky130_fd_sc_hd__dlygate4sd3_1
Xhold227 data\[0\]\[68\] VGND VGND VPWR VPWR net378 sky130_fd_sc_hd__dlygate4sd3_1
X_2147_ clknet_leaf_17_clk _0287_ VGND VGND VPWR VPWR data\[3\]\[71\] sky130_fd_sc_hd__dfxtp_1
X_2216_ clknet_leaf_26_clk _0356_ VGND VGND VPWR VPWR data\[1\]\[68\] sky130_fd_sc_hd__dfxtp_1
X_1029_ net149 VGND VGND VPWR VPWR _0850_ sky130_fd_sc_hd__buf_4
XTAP_TAPCELL_ROW_36_376 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_8_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2078_ clknet_leaf_25_clk _0218_ VGND VGND VPWR VPWR data\[3\]\[2\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_31_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_39_234 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1380_ net369 _0415_ _0518_ VGND VGND VPWR VPWR _0519_ sky130_fd_sc_hd__mux2_1
XFILLER_0_22_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2001_ clknet_leaf_26_clk _0141_ VGND VGND VPWR VPWR data\[0\]\[69\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_42_64 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_26_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_60_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1716_ net286 _0789_ _0692_ VGND VGND VPWR VPWR _0696_ sky130_fd_sc_hd__mux2_1
X_1647_ _0659_ VGND VGND VPWR VPWR _0258_ sky130_fd_sc_hd__clkbuf_1
X_1578_ _0611_ VGND VGND VPWR VPWR _0623_ sky130_fd_sc_hd__buf_4
XFILLER_0_44_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_4_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_59_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xoutput107 net107 VGND VGND VPWR VPWR rdata[37] sky130_fd_sc_hd__clkbuf_4
XFILLER_0_50_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_42_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_6_109 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1501_ net467 _0366_ _0575_ VGND VGND VPWR VPWR _0582_ sky130_fd_sc_hd__mux2_1
Xoutput118 net118 VGND VGND VPWR VPWR rdata[47] sky130_fd_sc_hd__clkbuf_4
XFILLER_0_49_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1363_ net182 _0388_ _0507_ VGND VGND VPWR VPWR _0510_ sky130_fd_sc_hd__mux2_1
XFILLER_0_37_20 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1432_ net482 _0824_ _0542_ VGND VGND VPWR VPWR _0546_ sky130_fd_sc_hd__mux2_1
Xoutput129 net129 VGND VGND VPWR VPWR rdata[57] sky130_fd_sc_hd__clkbuf_4
XPHY_EDGE_ROW_43_Left_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_37_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1294_ _0473_ VGND VGND VPWR VPWR _0091_ sky130_fd_sc_hd__clkbuf_1
XPHY_EDGE_ROW_52_Left_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_1_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_61_Left_126 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_64_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_64_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_52_474 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_32_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_9_196 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_59_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_55_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1981_ clknet_leaf_9_clk _0121_ VGND VGND VPWR VPWR data\[0\]\[49\] sky130_fd_sc_hd__dfxtp_1
X_0932_ data\[0\]\[0\] data\[1\]\[0\] data\[2\]\[0\] data\[3\]\[0\] _0771_ _0772_
+ VGND VGND VPWR VPWR _0773_ sky130_fd_sc_hd__mux4_1
XFILLER_0_15_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_2_101 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_262 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1346_ net357 _0360_ _0496_ VGND VGND VPWR VPWR _0501_ sky130_fd_sc_hd__mux2_1
XFILLER_0_47_6 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1415_ net478 _0794_ _0531_ VGND VGND VPWR VPWR _0537_ sky130_fd_sc_hd__mux2_1
X_1277_ net203 _0819_ _0463_ VGND VGND VPWR VPWR _0465_ sky130_fd_sc_hd__mux2_1
XFILLER_0_61_379 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_61_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_57_511 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_6_177 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_40_400 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_leaf_22_clk clknet_2_2__leaf_clk VGND VGND VPWR VPWR clknet_leaf_22_clk sky130_fd_sc_hd__clkbuf_8
X_2180_ clknet_leaf_12_clk _0320_ VGND VGND VPWR VPWR data\[1\]\[32\] sky130_fd_sc_hd__dfxtp_1
X_1200_ net428 _0411_ _0382_ VGND VGND VPWR VPWR _0412_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_63_547 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1131_ _0928_ VGND VGND VPWR VPWR _0043_ sky130_fd_sc_hd__clkbuf_1
X_1062_ data\[0\]\[28\] data\[1\]\[28\] data\[2\]\[28\] data\[3\]\[28\] _0867_ _0874_
+ VGND VGND VPWR VPWR _0875_ sky130_fd_sc_hd__mux4_1
X_1895_ clknet_leaf_8_clk _0035_ VGND VGND VPWR VPWR data\[2\]\[35\] sky130_fd_sc_hd__dfxtp_1
Xclkbuf_leaf_13_clk clknet_2_3__leaf_clk VGND VGND VPWR VPWR clknet_leaf_13_clk sky130_fd_sc_hd__clkbuf_8
X_1964_ clknet_leaf_11_clk _0104_ VGND VGND VPWR VPWR data\[0\]\[32\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_43_346 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_28_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_7_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1329_ net307 _0903_ _0485_ VGND VGND VPWR VPWR _0492_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_3_158 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_61_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_46_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold9 data\[3\]\[20\] VGND VGND VPWR VPWR net160 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_29_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_17_249 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_60_528 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1680_ _0676_ VGND VGND VPWR VPWR _0274_ sky130_fd_sc_hd__clkbuf_1
X_1114_ data\[0\]\[40\] data\[1\]\[40\] data\[2\]\[40\] data\[3\]\[40\] _0901_ _0908_
+ VGND VGND VPWR VPWR _0915_ sky130_fd_sc_hd__mux4_1
XFILLER_0_45_42 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkbuf_leaf_2_clk clknet_2_1__leaf_clk VGND VGND VPWR VPWR clknet_leaf_2_clk sky130_fd_sc_hd__clkbuf_8
X_2163_ clknet_leaf_20_clk _0303_ VGND VGND VPWR VPWR data\[1\]\[15\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_61_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1045_ net20 _0861_ _0848_ VGND VGND VPWR VPWR _0862_ sky130_fd_sc_hd__mux2_1
X_2094_ clknet_leaf_18_clk _0234_ VGND VGND VPWR VPWR data\[3\]\[18\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_0_139 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_0_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_43_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1878_ clknet_leaf_18_clk _0018_ VGND VGND VPWR VPWR data\[2\]\[18\] sky130_fd_sc_hd__dfxtp_1
X_1947_ clknet_leaf_20_clk _0087_ VGND VGND VPWR VPWR data\[0\]\[15\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_16_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_22_285 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_8_Left_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_57_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_15_34 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1801_ _0740_ VGND VGND VPWR VPWR _0331_ sky130_fd_sc_hd__clkbuf_1
Xhold206 data\[0\]\[44\] VGND VGND VPWR VPWR net357 sky130_fd_sc_hd__dlygate4sd3_1
Xhold217 data\[1\]\[47\] VGND VGND VPWR VPWR net368 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_40_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1663_ net178 _0381_ _0667_ VGND VGND VPWR VPWR _0668_ sky130_fd_sc_hd__mux2_1
XFILLER_0_31_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_25_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_13_305 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1732_ _0704_ VGND VGND VPWR VPWR _0298_ sky130_fd_sc_hd__clkbuf_1
Xhold228 data\[0\]\[43\] VGND VGND VPWR VPWR net379 sky130_fd_sc_hd__dlygate4sd3_1
Xhold239 data\[0\]\[29\] VGND VGND VPWR VPWR net390 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_40_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_7_Right_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1594_ _0631_ VGND VGND VPWR VPWR _0233_ sky130_fd_sc_hd__clkbuf_1
X_2146_ clknet_leaf_2_clk _0286_ VGND VGND VPWR VPWR data\[3\]\[70\] sky130_fd_sc_hd__dfxtp_1
X_2077_ clknet_leaf_27_clk _0217_ VGND VGND VPWR VPWR data\[3\]\[1\] sky130_fd_sc_hd__dfxtp_1
X_2215_ clknet_leaf_1_clk _0355_ VGND VGND VPWR VPWR data\[1\]\[67\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_48_268 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1028_ net16 _0847_ _0848_ VGND VGND VPWR VPWR _0849_ sky130_fd_sc_hd__mux2_1
XFILLER_0_8_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_16_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_34_Left_99 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2000_ clknet_leaf_26_clk _0140_ VGND VGND VPWR VPWR data\[0\]\[68\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_42_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1646_ net161 _0924_ _0656_ VGND VGND VPWR VPWR _0659_ sky130_fd_sc_hd__mux2_1
XFILLER_0_5_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_13_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1715_ _0695_ VGND VGND VPWR VPWR _0290_ sky130_fd_sc_hd__clkbuf_1
X_1577_ _0622_ VGND VGND VPWR VPWR _0225_ sky130_fd_sc_hd__clkbuf_1
X_2129_ clknet_leaf_2_clk _0269_ VGND VGND VPWR VPWR data\[3\]\[53\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_8_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_8_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_55_494 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xoutput108 net108 VGND VGND VPWR VPWR rdata[38] sky130_fd_sc_hd__clkbuf_4
X_1500_ _0581_ VGND VGND VPWR VPWR _0189_ sky130_fd_sc_hd__clkbuf_1
Xoutput119 net119 VGND VGND VPWR VPWR rdata[48] sky130_fd_sc_hd__clkbuf_4
Xoutput90 net90 VGND VGND VPWR VPWR rdata[21] sky130_fd_sc_hd__clkbuf_4
X_1362_ _0509_ VGND VGND VPWR VPWR _0123_ sky130_fd_sc_hd__clkbuf_1
X_1293_ net391 _0845_ _0463_ VGND VGND VPWR VPWR _0473_ sky130_fd_sc_hd__mux2_1
X_1431_ _0545_ VGND VGND VPWR VPWR _0156_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_53_86 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_58_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1629_ net346 _0896_ _0645_ VGND VGND VPWR VPWR _0650_ sky130_fd_sc_hd__mux2_1
XFILLER_0_64_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_52_475 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_49_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_64_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_9_197 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_55_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_43_420 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1980_ clknet_leaf_3_clk _0120_ VGND VGND VPWR VPWR data\[0\]\[48\] sky130_fd_sc_hd__dfxtp_1
X_0931_ net2 VGND VGND VPWR VPWR _0772_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_2_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_2_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_21_Left_86 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_23_285 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_64_41 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1345_ _0500_ VGND VGND VPWR VPWR _0115_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_3_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_3_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1276_ _0464_ VGND VGND VPWR VPWR _0082_ sky130_fd_sc_hd__clkbuf_1
X_1414_ _0536_ VGND VGND VPWR VPWR _0148_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_64_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_14_230 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_57_512 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_6_178 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_64_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_40_401 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1130_ net325 _0927_ _0918_ VGND VGND VPWR VPWR _0928_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_63_548 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_47_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1061_ _0805_ VGND VGND VPWR VPWR _0874_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_34_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1963_ clknet_leaf_13_clk _0103_ VGND VGND VPWR VPWR data\[0\]\[31\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_55_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_50_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1894_ clknet_leaf_10_clk _0034_ VGND VGND VPWR VPWR data\[2\]\[34\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_28_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_59_96 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_59_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1328_ _0491_ VGND VGND VPWR VPWR _0107_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_3_159 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1259_ _0455_ VGND VGND VPWR VPWR _0074_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_60_529 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_37_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1113_ _0914_ VGND VGND VPWR VPWR _0039_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_45_76 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_45_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1044_ data\[0\]\[24\] data\[1\]\[24\] data\[2\]\[24\] data\[3\]\[24\] _0833_ _0840_
+ VGND VGND VPWR VPWR _0861_ sky130_fd_sc_hd__mux4_1
XFILLER_0_29_99 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2162_ clknet_leaf_21_clk _0302_ VGND VGND VPWR VPWR data\[1\]\[14\] sky130_fd_sc_hd__dfxtp_1
X_2093_ clknet_leaf_18_clk _0233_ VGND VGND VPWR VPWR data\[3\]\[17\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_24_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_61_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_43_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_43_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_31_306 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1946_ clknet_leaf_21_clk _0086_ VGND VGND VPWR VPWR data\[0\]\[14\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_9_76 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1877_ clknet_leaf_18_clk _0017_ VGND VGND VPWR VPWR data\[2\]\[17\] sky130_fd_sc_hd__dfxtp_1
X_1800_ net250 _0927_ _0736_ VGND VGND VPWR VPWR _0740_ sky130_fd_sc_hd__mux2_1
XFILLER_0_57_258 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_57_236 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_15_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xhold207 data\[2\]\[40\] VGND VGND VPWR VPWR net358 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_31_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_31_67 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1662_ _0611_ VGND VGND VPWR VPWR _0667_ sky130_fd_sc_hd__buf_4
Xhold229 data\[0\]\[64\] VGND VGND VPWR VPWR net380 sky130_fd_sc_hd__dlygate4sd3_1
Xhold218 data\[0\]\[60\] VGND VGND VPWR VPWR net369 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_13_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1731_ net396 _0815_ _0703_ VGND VGND VPWR VPWR _0704_ sky130_fd_sc_hd__mux2_1
X_2214_ clknet_leaf_30_clk _0354_ VGND VGND VPWR VPWR data\[1\]\[66\] sky130_fd_sc_hd__dfxtp_1
X_1593_ net200 _0838_ _0623_ VGND VGND VPWR VPWR _0631_ sky130_fd_sc_hd__mux2_1
X_1027_ _0774_ VGND VGND VPWR VPWR _0848_ sky130_fd_sc_hd__buf_4
X_2076_ clknet_leaf_27_clk _0216_ VGND VGND VPWR VPWR data\[3\]\[0\] sky130_fd_sc_hd__dfxtp_1
X_2145_ clknet_leaf_26_clk _0285_ VGND VGND VPWR VPWR data\[3\]\[69\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_8_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1929_ clknet_leaf_28_clk _0069_ VGND VGND VPWR VPWR data\[2\]\[69\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_31_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_39_258 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_27_312 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_10_201 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_22_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_10_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xhold90 data\[2\]\[68\] VGND VGND VPWR VPWR net241 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_9_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1645_ _0658_ VGND VGND VPWR VPWR _0257_ sky130_fd_sc_hd__clkbuf_1
X_1714_ net181 _0786_ _0692_ VGND VGND VPWR VPWR _0695_ sky130_fd_sc_hd__mux2_1
X_1576_ net244 _0811_ _0612_ VGND VGND VPWR VPWR _0622_ sky130_fd_sc_hd__mux2_1
XFILLER_0_21_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2128_ clknet_leaf_3_clk _0268_ VGND VGND VPWR VPWR data\[3\]\[52\] sky130_fd_sc_hd__dfxtp_1
X_2059_ clknet_leaf_3_clk _0199_ VGND VGND VPWR VPWR net127 sky130_fd_sc_hd__dfxtp_1
XFILLER_0_36_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_8_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_55_495 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_27_228 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xoutput109 net109 VGND VGND VPWR VPWR rdata[39] sky130_fd_sc_hd__clkbuf_4
X_1430_ net465 _0821_ _0542_ VGND VGND VPWR VPWR _0545_ sky130_fd_sc_hd__mux2_1
Xoutput91 net91 VGND VGND VPWR VPWR rdata[22] sky130_fd_sc_hd__buf_2
X_1361_ net439 _0385_ _0507_ VGND VGND VPWR VPWR _0509_ sky130_fd_sc_hd__mux2_1
X_1292_ _0472_ VGND VGND VPWR VPWR _0090_ sky130_fd_sc_hd__clkbuf_1
Xoutput80 net80 VGND VGND VPWR VPWR rdata[12] sky130_fd_sc_hd__clkbuf_4
XTAP_TAPCELL_ROW_46_440 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_41_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_5_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1628_ _0649_ VGND VGND VPWR VPWR _0249_ sky130_fd_sc_hd__clkbuf_1
X_1559_ _0613_ VGND VGND VPWR VPWR _0216_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_1_361 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_52_476 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_32_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_32_264 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_32_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_9_198 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_43_421 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_55_312 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_0930_ net1 VGND VGND VPWR VPWR _0771_ sky130_fd_sc_hd__buf_4
XFILLER_0_23_57 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_48_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1413_ net488 _0791_ _0531_ VGND VGND VPWR VPWR _0536_ sky130_fd_sc_hd__mux2_1
XFILLER_0_64_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_64_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1344_ net379 _0927_ _0496_ VGND VGND VPWR VPWR _0500_ sky130_fd_sc_hd__mux2_1
X_1275_ net397 _0815_ _0463_ VGND VGND VPWR VPWR _0464_ sky130_fd_sc_hd__mux2_1
XFILLER_0_58_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_46_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_61_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_14_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_6_179 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_29_Right_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_64_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_64_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_40_402 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_38_Right_38 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_37_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_37_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_20_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1060_ _0873_ VGND VGND VPWR VPWR _0027_ sky130_fd_sc_hd__clkbuf_1
XPHY_EDGE_ROW_47_Right_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_18_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_18_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_18_68 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_63_549 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_56_Right_56 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1962_ clknet_leaf_10_clk _0102_ VGND VGND VPWR VPWR data\[0\]\[30\] sky130_fd_sc_hd__dfxtp_1
X_1893_ clknet_leaf_12_clk _0033_ VGND VGND VPWR VPWR data\[2\]\[33\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_51_370 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_43_326 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_43_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_11_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1327_ net399 _0899_ _0485_ VGND VGND VPWR VPWR _0491_ sky130_fd_sc_hd__mux2_1
X_1189_ data\[0\]\[57\] data\[1\]\[57\] data\[2\]\[57\] data\[3\]\[57\] _0399_ _0372_
+ VGND VGND VPWR VPWR _0403_ sky130_fd_sc_hd__mux4_1
X_1258_ net195 _0786_ _0452_ VGND VGND VPWR VPWR _0455_ sky130_fd_sc_hd__mux2_1
XPHY_EDGE_ROW_49_Left_114 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_46_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_46_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_34_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_61_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_58_Left_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_52_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_25_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1112_ net408 _0913_ _0884_ VGND VGND VPWR VPWR _0914_ sky130_fd_sc_hd__mux2_1
XFILLER_0_45_88 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_45_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1043_ _0860_ VGND VGND VPWR VPWR _0023_ sky130_fd_sc_hd__clkbuf_1
X_2092_ clknet_leaf_17_clk _0232_ VGND VGND VPWR VPWR data\[3\]\[16\] sky130_fd_sc_hd__dfxtp_1
X_2161_ clknet_leaf_19_clk _0301_ VGND VGND VPWR VPWR data\[1\]\[13\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_43_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_28_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_0_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_16_240 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1945_ clknet_leaf_20_clk _0085_ VGND VGND VPWR VPWR data\[0\]\[13\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_31_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_31_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1876_ clknet_leaf_17_clk _0016_ VGND VGND VPWR VPWR data\[2\]\[16\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_9_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_9_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_10_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_34_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_19_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_19_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_31_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_13_221 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xhold208 data\[3\]\[31\] VGND VGND VPWR VPWR net359 sky130_fd_sc_hd__dlygate4sd3_1
Xhold219 data\[1\]\[41\] VGND VGND VPWR VPWR net370 sky130_fd_sc_hd__dlygate4sd3_1
X_1661_ _0666_ VGND VGND VPWR VPWR _0265_ sky130_fd_sc_hd__clkbuf_1
X_1592_ _0630_ VGND VGND VPWR VPWR _0232_ sky130_fd_sc_hd__clkbuf_1
X_1730_ _0691_ VGND VGND VPWR VPWR _0703_ sky130_fd_sc_hd__buf_4
XFILLER_0_25_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_0_212 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_56_54 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_267 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2144_ clknet_leaf_1_clk _0284_ VGND VGND VPWR VPWR data\[3\]\[68\] sky130_fd_sc_hd__dfxtp_1
X_2213_ clknet_leaf_0_clk _0353_ VGND VGND VPWR VPWR data\[1\]\[65\] sky130_fd_sc_hd__dfxtp_1
X_1026_ data\[0\]\[20\] data\[1\]\[20\] data\[2\]\[20\] data\[3\]\[20\] _0833_ _0840_
+ VGND VGND VPWR VPWR _0847_ sky130_fd_sc_hd__mux4_1
X_2075_ clknet_leaf_17_clk _0215_ VGND VGND VPWR VPWR net145 sky130_fd_sc_hd__dfxtp_1
XFILLER_0_15_6 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1859_ _0770_ VGND VGND VPWR VPWR _0359_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_8_323 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_16_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_16_112 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1928_ clknet_leaf_26_clk _0068_ VGND VGND VPWR VPWR data\[2\]\[68\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_31_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_12_340 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_27_313 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_47_292 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_62_273 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_10_202 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xhold91 net90 VGND VGND VPWR VPWR net242 sky130_fd_sc_hd__dlygate4sd3_1
Xhold80 data\[0\]\[12\] VGND VGND VPWR VPWR net231 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_5_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1713_ _0694_ VGND VGND VPWR VPWR _0289_ sky130_fd_sc_hd__clkbuf_1
X_1644_ net434 _0921_ _0656_ VGND VGND VPWR VPWR _0658_ sky130_fd_sc_hd__mux2_1
XFILLER_0_6_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1575_ _0621_ VGND VGND VPWR VPWR _0224_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_49_460 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2127_ clknet_leaf_2_clk _0267_ VGND VGND VPWR VPWR data\[3\]\[51\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_13_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_2058_ clknet_leaf_4_clk _0198_ VGND VGND VPWR VPWR net126 sky130_fd_sc_hd__dfxtp_1
XFILLER_0_29_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1009_ data\[0\]\[16\] data\[1\]\[16\] data\[2\]\[16\] data\[3\]\[16\] _0833_ _0806_
+ VGND VGND VPWR VPWR _0834_ sky130_fd_sc_hd__mux4_1
XFILLER_0_44_262 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_55_496 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_35_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_12_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1360_ _0508_ VGND VGND VPWR VPWR _0122_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_2_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xoutput92 net92 VGND VGND VPWR VPWR rdata[23] sky130_fd_sc_hd__buf_2
X_1291_ net273 _0842_ _0463_ VGND VGND VPWR VPWR _0472_ sky130_fd_sc_hd__mux2_1
Xoutput81 net81 VGND VGND VPWR VPWR rdata[13] sky130_fd_sc_hd__buf_2
XFILLER_0_58_365 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_58_321 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_46_441 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_41_254 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_5_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1627_ net211 _0893_ _0645_ VGND VGND VPWR VPWR _0649_ sky130_fd_sc_hd__mux2_1
X_1489_ net474 _0915_ _0575_ VGND VGND VPWR VPWR _0576_ sky130_fd_sc_hd__mux2_1
X_1558_ net288 _0776_ _0612_ VGND VGND VPWR VPWR _0613_ sky130_fd_sc_hd__mux2_1
XFILLER_0_1_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_52_477 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_2_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_9_199 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_leaf_25_clk clknet_2_0__leaf_clk VGND VGND VPWR VPWR clknet_leaf_25_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_0_23_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_55_368 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_23_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1343_ _0499_ VGND VGND VPWR VPWR _0114_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_48_88 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1412_ _0535_ VGND VGND VPWR VPWR _0147_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_64_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1274_ net151 VGND VGND VPWR VPWR _0463_ sky130_fd_sc_hd__buf_4
XFILLER_0_61_305 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_46_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkbuf_leaf_16_clk clknet_2_3__leaf_clk VGND VGND VPWR VPWR clknet_leaf_16_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_0_61_349 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0989_ net6 _0818_ _0814_ VGND VGND VPWR VPWR _0819_ sky130_fd_sc_hd__mux2_1
XFILLER_0_64_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_52_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_9_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1961_ clknet_leaf_13_clk _0101_ VGND VGND VPWR VPWR data\[0\]\[29\] sky130_fd_sc_hd__dfxtp_1
X_1892_ clknet_leaf_10_clk _0032_ VGND VGND VPWR VPWR data\[2\]\[32\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_59_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_11_235 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkbuf_leaf_5_clk clknet_2_1__leaf_clk VGND VGND VPWR VPWR clknet_leaf_5_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_0_45_6 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1326_ _0490_ VGND VGND VPWR VPWR _0106_ sky130_fd_sc_hd__clkbuf_1
X_1188_ _0402_ VGND VGND VPWR VPWR _0056_ sky130_fd_sc_hd__clkbuf_1
X_1257_ _0454_ VGND VGND VPWR VPWR _0073_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_19_260 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_6_284 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_19_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_19_368 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_2_150 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_52_102 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_52_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2160_ clknet_leaf_22_clk _0300_ VGND VGND VPWR VPWR data\[1\]\[12\] sky130_fd_sc_hd__dfxtp_1
X_1111_ net36 _0912_ _0882_ VGND VGND VPWR VPWR _0913_ sky130_fd_sc_hd__mux2_1
X_1042_ net375 _0859_ _0850_ VGND VGND VPWR VPWR _0860_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_16_241 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_2091_ clknet_leaf_20_clk _0231_ VGND VGND VPWR VPWR data\[3\]\[15\] sky130_fd_sc_hd__dfxtp_1
X_1944_ clknet_leaf_22_clk _0084_ VGND VGND VPWR VPWR data\[0\]\[12\] sky130_fd_sc_hd__dfxtp_1
X_1875_ clknet_leaf_20_clk _0015_ VGND VGND VPWR VPWR data\[2\]\[15\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_24_382 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1309_ _0481_ VGND VGND VPWR VPWR _0098_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_43_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_19_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_19_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_30_341 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_25_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_13_222 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1660_ net253 _0377_ _0656_ VGND VGND VPWR VPWR _0666_ sky130_fd_sc_hd__mux2_1
XFILLER_0_40_127 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1591_ net254 _0835_ _0623_ VGND VGND VPWR VPWR _0630_ sky130_fd_sc_hd__mux2_1
XFILLER_0_0_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold209 data\[0\]\[66\] VGND VGND VPWR VPWR net360 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_56_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_2212_ clknet_leaf_29_clk _0352_ VGND VGND VPWR VPWR data\[1\]\[64\] sky130_fd_sc_hd__dfxtp_1
X_2143_ clknet_leaf_30_clk _0283_ VGND VGND VPWR VPWR data\[3\]\[67\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_48_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_48_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2074_ clknet_leaf_10_clk _0214_ VGND VGND VPWR VPWR net144 sky130_fd_sc_hd__dfxtp_1
X_1025_ _0846_ VGND VGND VPWR VPWR _0019_ sky130_fd_sc_hd__clkbuf_1
X_1858_ net291 _0449_ net150 VGND VGND VPWR VPWR _0770_ sky130_fd_sc_hd__mux2_1
XFILLER_0_16_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1927_ clknet_leaf_30_clk _0067_ VGND VGND VPWR VPWR data\[2\]\[67\] sky130_fd_sc_hd__dfxtp_1
X_1789_ net355 _0910_ _0725_ VGND VGND VPWR VPWR _0734_ sky130_fd_sc_hd__mux2_1
XFILLER_0_12_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_27_314 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_10_203 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_62_285 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold70 data\[0\]\[42\] VGND VGND VPWR VPWR net221 sky130_fd_sc_hd__dlygate4sd3_1
Xhold81 data\[1\]\[0\] VGND VGND VPWR VPWR net232 sky130_fd_sc_hd__dlygate4sd3_1
Xhold92 data\[1\]\[7\] VGND VGND VPWR VPWR net243 sky130_fd_sc_hd__dlygate4sd3_1
X_1643_ _0657_ VGND VGND VPWR VPWR _0256_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_42_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_38_282 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_5_349 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_305 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1712_ net162 _0783_ _0692_ VGND VGND VPWR VPWR _0694_ sky130_fd_sc_hd__mux2_1
X_1574_ net298 _0808_ _0612_ VGND VGND VPWR VPWR _0621_ sky130_fd_sc_hd__mux2_1
X_2057_ clknet_leaf_10_clk _0197_ VGND VGND VPWR VPWR net125 sky130_fd_sc_hd__dfxtp_1
X_2126_ clknet_leaf_3_clk _0266_ VGND VGND VPWR VPWR data\[3\]\[50\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_16_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1008_ _0797_ VGND VGND VPWR VPWR _0833_ sky130_fd_sc_hd__buf_4
XTAP_TAPCELL_ROW_32_350 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_55_497 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_12_38 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xoutput93 net93 VGND VGND VPWR VPWR rdata[24] sky130_fd_sc_hd__buf_2
Xoutput82 net82 VGND VGND VPWR VPWR rdata[14] sky130_fd_sc_hd__clkbuf_4
XFILLER_0_37_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1290_ _0471_ VGND VGND VPWR VPWR _0089_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_58_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_58_333 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_102 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1626_ _0648_ VGND VGND VPWR VPWR _0248_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_41_200 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_5_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1488_ _0778_ VGND VGND VPWR VPWR _0575_ sky130_fd_sc_hd__buf_4
X_1557_ _0611_ VGND VGND VPWR VPWR _0612_ sky130_fd_sc_hd__buf_4
X_2109_ clknet_leaf_12_clk _0249_ VGND VGND VPWR VPWR data\[3\]\[33\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_64_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_52_478 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_59_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_2_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1342_ net221 _0924_ _0496_ VGND VGND VPWR VPWR _0499_ sky130_fd_sc_hd__mux2_1
X_1411_ net504 _0788_ _0531_ VGND VGND VPWR VPWR _0535_ sky130_fd_sc_hd__mux2_1
X_1273_ _0462_ VGND VGND VPWR VPWR _0081_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_61_317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0988_ data\[0\]\[11\] data\[1\]\[11\] data\[2\]\[11\] data\[3\]\[11\] _0798_ _0806_
+ VGND VGND VPWR VPWR _0818_ sky130_fd_sc_hd__mux4_1
X_1609_ _0639_ VGND VGND VPWR VPWR _0240_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_64_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_18_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_5_170 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1891_ clknet_leaf_12_clk _0031_ VGND VGND VPWR VPWR data\[2\]\[31\] sky130_fd_sc_hd__dfxtp_1
X_1960_ clknet_leaf_13_clk _0100_ VGND VGND VPWR VPWR data\[0\]\[28\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_59_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_11_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1325_ net411 _0896_ _0485_ VGND VGND VPWR VPWR _0490_ sky130_fd_sc_hd__mux2_1
XFILLER_0_38_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1256_ net403 _0783_ _0452_ VGND VGND VPWR VPWR _0454_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_62_540 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1187_ net422 _0401_ _0382_ VGND VGND VPWR VPWR _0402_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_19_261 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_61_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_34_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_6_296 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_2_151 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_52_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_52_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1110_ data\[0\]\[39\] data\[1\]\[39\] data\[2\]\[39\] data\[3\]\[39\] _0901_ _0908_
+ VGND VGND VPWR VPWR _0912_ sky130_fd_sc_hd__mux4_1
X_2090_ clknet_leaf_20_clk _0230_ VGND VGND VPWR VPWR data\[3\]\[14\] sky130_fd_sc_hd__dfxtp_1
X_1041_ net19 _0858_ _0848_ VGND VGND VPWR VPWR _0859_ sky130_fd_sc_hd__mux2_1
XFILLER_0_0_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_16_242 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_43_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_3_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1874_ clknet_leaf_21_clk _0014_ VGND VGND VPWR VPWR data\[2\]\[14\] sky130_fd_sc_hd__dfxtp_1
X_1943_ clknet_leaf_21_clk _0083_ VGND VGND VPWR VPWR data\[0\]\[11\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_3_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1308_ net354 _0869_ _0474_ VGND VGND VPWR VPWR _0481_ sky130_fd_sc_hd__mux2_1
X_1239_ _0441_ VGND VGND VPWR VPWR _0068_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_25_169 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_13_223 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1590_ _0629_ VGND VGND VPWR VPWR _0231_ sky130_fd_sc_hd__clkbuf_1
X_1024_ net351 _0845_ _0816_ VGND VGND VPWR VPWR _0846_ sky130_fd_sc_hd__mux2_1
X_2211_ clknet_leaf_30_clk _0351_ VGND VGND VPWR VPWR data\[1\]\[63\] sky130_fd_sc_hd__dfxtp_1
X_2142_ clknet_leaf_30_clk _0282_ VGND VGND VPWR VPWR data\[3\]\[66\] sky130_fd_sc_hd__dfxtp_1
X_2073_ clknet_leaf_26_clk _0213_ VGND VGND VPWR VPWR net142 sky130_fd_sc_hd__dfxtp_1
XFILLER_0_22_9 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_48_228 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_28_Left_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1788_ _0733_ VGND VGND VPWR VPWR _0325_ sky130_fd_sc_hd__clkbuf_1
X_1857_ _0769_ VGND VGND VPWR VPWR _0358_ sky130_fd_sc_hd__clkbuf_1
X_1926_ clknet_leaf_28_clk _0066_ VGND VGND VPWR VPWR data\[2\]\[66\] sky130_fd_sc_hd__dfxtp_1
XPHY_EDGE_ROW_12_Left_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_16_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_39_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_27_315 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_62_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_62_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_47_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_10_204 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_62_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_22_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold60 data\[3\]\[33\] VGND VGND VPWR VPWR net211 sky130_fd_sc_hd__dlygate4sd3_1
Xhold82 data\[1\]\[36\] VGND VGND VPWR VPWR net233 sky130_fd_sc_hd__dlygate4sd3_1
Xhold71 data\[1\]\[16\] VGND VGND VPWR VPWR net222 sky130_fd_sc_hd__dlygate4sd3_1
Xhold93 data\[3\]\[9\] VGND VGND VPWR VPWR net244 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_53_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_53_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1642_ net260 _0917_ _0656_ VGND VGND VPWR VPWR _0657_ sky130_fd_sc_hd__mux2_1
XFILLER_0_5_317 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1711_ _0693_ VGND VGND VPWR VPWR _0288_ sky130_fd_sc_hd__clkbuf_1
X_1573_ _0620_ VGND VGND VPWR VPWR _0223_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_21_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2125_ clknet_leaf_3_clk _0265_ VGND VGND VPWR VPWR data\[3\]\[49\] sky130_fd_sc_hd__dfxtp_1
X_2056_ clknet_leaf_2_clk _0196_ VGND VGND VPWR VPWR net124 sky130_fd_sc_hd__dfxtp_1
X_1007_ _0832_ VGND VGND VPWR VPWR _0015_ sky130_fd_sc_hd__clkbuf_1
X_1909_ clknet_leaf_3_clk _0049_ VGND VGND VPWR VPWR data\[2\]\[49\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_8_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_12_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_55_498 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_50_256 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_35_231 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_35_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_2_309 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput94 net94 VGND VGND VPWR VPWR rdata[25] sky130_fd_sc_hd__clkbuf_4
Xoutput83 net83 VGND VGND VPWR VPWR rdata[15] sky130_fd_sc_hd__buf_2
XFILLER_0_58_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_53_68 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_53_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_53_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_58_345 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1625_ net261 _0890_ _0645_ VGND VGND VPWR VPWR _0648_ sky130_fd_sc_hd__mux2_1
XFILLER_0_41_267 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_41_234 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1556_ _0610_ VGND VGND VPWR VPWR _0611_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_5_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1487_ _0574_ VGND VGND VPWR VPWR _0183_ sky130_fd_sc_hd__clkbuf_1
X_2039_ clknet_leaf_12_clk _0179_ VGND VGND VPWR VPWR net105 sky130_fd_sc_hd__dfxtp_1
X_2108_ clknet_leaf_11_clk _0248_ VGND VGND VPWR VPWR data\[3\]\[32\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_64_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_52_479 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_17_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_15_Left_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_55_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_63_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1410_ _0534_ VGND VGND VPWR VPWR _0146_ sky130_fd_sc_hd__clkbuf_1
X_1341_ _0498_ VGND VGND VPWR VPWR _0113_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_3_15 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_8_190 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1272_ net412 _0811_ _0452_ VGND VGND VPWR VPWR _0462_ sky130_fd_sc_hd__mux2_1
XFILLER_0_58_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_61_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_58_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_46_326 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_0987_ _0817_ VGND VGND VPWR VPWR _0010_ sky130_fd_sc_hd__clkbuf_1
X_1608_ net448 _0862_ _0634_ VGND VGND VPWR VPWR _0639_ sky130_fd_sc_hd__mux2_1
XFILLER_0_1_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1539_ net444 _0427_ _0597_ VGND VGND VPWR VPWR _0602_ sky130_fd_sc_hd__mux2_1
XFILLER_0_14_289 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_52_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_37_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_20_215 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
Xhold190 data\[3\]\[53\] VGND VGND VPWR VPWR net341 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_5_171 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_0_Left_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_16_Right_16 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1890_ clknet_leaf_10_clk _0030_ VGND VGND VPWR VPWR data\[2\]\[30\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_28_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_25_Right_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1324_ _0489_ VGND VGND VPWR VPWR _0105_ sky130_fd_sc_hd__clkbuf_1
XPHY_EDGE_ROW_34_Right_34 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1186_ net55 _0400_ _0380_ VGND VGND VPWR VPWR _0401_ sky130_fd_sc_hd__mux2_1
X_1255_ _0453_ VGND VGND VPWR VPWR _0072_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_62_541 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_46_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_19_262 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_19_337 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_61_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_43_Right_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_42_351 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_52_Right_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_10_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_2_152 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_61_Right_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_37_156 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_36_Left_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_45_Left_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1040_ data\[0\]\[23\] data\[1\]\[23\] data\[2\]\[23\] data\[3\]\[23\] _0833_ _0840_
+ VGND VGND VPWR VPWR _0858_ sky130_fd_sc_hd__mux4_1
XFILLER_0_61_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_61_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_0_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1942_ clknet_leaf_20_clk _0082_ VGND VGND VPWR VPWR data\[0\]\[10\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_16_243 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_3_256 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_9_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1873_ clknet_leaf_20_clk _0013_ VGND VGND VPWR VPWR data\[2\]\[13\] sky130_fd_sc_hd__dfxtp_1
X_1169_ net51 _0387_ _0380_ VGND VGND VPWR VPWR _0388_ sky130_fd_sc_hd__mux2_1
XFILLER_0_35_91 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1307_ _0480_ VGND VGND VPWR VPWR _0097_ sky130_fd_sc_hd__clkbuf_1
X_1238_ net241 _0440_ _0416_ VGND VGND VPWR VPWR _0441_ sky130_fd_sc_hd__mux2_1
XFILLER_0_59_281 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_51_90 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_34_126 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_22_279 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_30_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_13_224 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_31_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2210_ clknet_leaf_27_clk _0350_ VGND VGND VPWR VPWR data\[1\]\[62\] sky130_fd_sc_hd__dfxtp_1
X_1023_ net14 _0844_ _0814_ VGND VGND VPWR VPWR _0845_ sky130_fd_sc_hd__mux2_1
X_2141_ clknet_leaf_30_clk _0281_ VGND VGND VPWR VPWR data\[3\]\[65\] sky130_fd_sc_hd__dfxtp_1
X_2072_ clknet_leaf_26_clk _0212_ VGND VGND VPWR VPWR net141 sky130_fd_sc_hd__dfxtp_1
XFILLER_0_56_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_8_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1925_ clknet_leaf_30_clk _0065_ VGND VGND VPWR VPWR data\[2\]\[65\] sky130_fd_sc_hd__dfxtp_1
X_1787_ net301 _0906_ _0725_ VGND VGND VPWR VPWR _0733_ sky130_fd_sc_hd__mux2_1
X_1856_ net362 _0446_ net150 VGND VGND VPWR VPWR _0769_ sky130_fd_sc_hd__mux2_1
XFILLER_0_12_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_2_Right_2 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_27_316 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_1_81 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_47_262 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_10_205 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_30_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold72 data\[1\]\[32\] VGND VGND VPWR VPWR net223 sky130_fd_sc_hd__dlygate4sd3_1
Xhold61 data\[0\]\[30\] VGND VGND VPWR VPWR net212 sky130_fd_sc_hd__dlygate4sd3_1
Xhold50 data\[1\]\[54\] VGND VGND VPWR VPWR net201 sky130_fd_sc_hd__dlygate4sd3_1
Xhold83 data\[2\]\[71\] VGND VGND VPWR VPWR net234 sky130_fd_sc_hd__dlygate4sd3_1
Xhold94 data\[2\]\[2\] VGND VGND VPWR VPWR net245 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_38_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_5_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1641_ _0611_ VGND VGND VPWR VPWR _0656_ sky130_fd_sc_hd__buf_4
XFILLER_0_6_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1710_ net232 _0776_ _0692_ VGND VGND VPWR VPWR _0693_ sky130_fd_sc_hd__mux2_1
X_1572_ net249 _0803_ _0612_ VGND VGND VPWR VPWR _0620_ sky130_fd_sc_hd__mux2_1
X_2124_ clknet_leaf_4_clk _0264_ VGND VGND VPWR VPWR data\[3\]\[48\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_21_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2055_ clknet_leaf_2_clk _0195_ VGND VGND VPWR VPWR net123 sky130_fd_sc_hd__dfxtp_1
XFILLER_0_16_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1006_ net367 _0831_ _0816_ VGND VGND VPWR VPWR _0832_ sky130_fd_sc_hd__mux2_1
XFILLER_0_44_287 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1908_ clknet_leaf_4_clk _0048_ VGND VGND VPWR VPWR data\[2\]\[48\] sky130_fd_sc_hd__dfxtp_1
X_1839_ _0760_ VGND VGND VPWR VPWR _0349_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_8_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_55_499 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_35_298 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_35_243 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xoutput95 net95 VGND VGND VPWR VPWR rdata[26] sky130_fd_sc_hd__buf_2
Xoutput84 net84 VGND VGND VPWR VPWR rdata[16] sky130_fd_sc_hd__clkbuf_4
XFILLER_0_58_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkbuf_leaf_28_clk clknet_2_0__leaf_clk VGND VGND VPWR VPWR clknet_leaf_28_clk sky130_fd_sc_hd__clkbuf_8
X_1624_ _0647_ VGND VGND VPWR VPWR _0247_ sky130_fd_sc_hd__clkbuf_1
X_1555_ _0777_ _0805_ _0771_ VGND VGND VPWR VPWR _0610_ sky130_fd_sc_hd__and3b_1
X_2107_ clknet_leaf_12_clk _0247_ VGND VGND VPWR VPWR data\[3\]\[31\] sky130_fd_sc_hd__dfxtp_1
X_1486_ net491 _0912_ _0564_ VGND VGND VPWR VPWR _0574_ sky130_fd_sc_hd__mux2_1
Xclkbuf_leaf_19_clk clknet_2_2__leaf_clk VGND VGND VPWR VPWR clknet_leaf_19_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_0_64_349 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_49_313 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2038_ clknet_leaf_16_clk _0178_ VGND VGND VPWR VPWR net104 sky130_fd_sc_hd__dfxtp_1
XFILLER_0_32_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xhold350 net92 VGND VGND VPWR VPWR net501 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_48_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1340_ net384 _0921_ _0496_ VGND VGND VPWR VPWR _0498_ sky130_fd_sc_hd__mux2_1
XFILLER_0_64_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_48_69 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_3_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_8_191 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1271_ _0461_ VGND VGND VPWR VPWR _0080_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_46_338 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkbuf_leaf_8_clk clknet_2_1__leaf_clk VGND VGND VPWR VPWR clknet_leaf_8_clk sky130_fd_sc_hd__clkbuf_8
X_0986_ net188 _0815_ _0816_ VGND VGND VPWR VPWR _0817_ sky130_fd_sc_hd__mux2_1
XFILLER_0_59_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
X_1469_ _0565_ VGND VGND VPWR VPWR _0174_ sky130_fd_sc_hd__clkbuf_1
X_1607_ _0638_ VGND VGND VPWR VPWR _0239_ sky130_fd_sc_hd__clkbuf_1
X_1538_ _0601_ VGND VGND VPWR VPWR _0207_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_64_146 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_64_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_64_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_49_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_37_316 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_60_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold180 data\[3\]\[69\] VGND VGND VPWR VPWR net331 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_20_227 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold191 data\[1\]\[24\] VGND VGND VPWR VPWR net342 sky130_fd_sc_hd__dlygate4sd3_1
XTAP_TAPCELL_ROW_5_172 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_0_3 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_55_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_36_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1323_ net374 _0893_ _0485_ VGND VGND VPWR VPWR _0489_ sky130_fd_sc_hd__mux2_1
X_1185_ data\[0\]\[56\] data\[1\]\[56\] data\[2\]\[56\] data\[3\]\[56\] _0399_ _0372_
+ VGND VGND VPWR VPWR _0400_ sky130_fd_sc_hd__mux4_1
X_1254_ net395 _0776_ _0452_ VGND VGND VPWR VPWR _0453_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_19_263 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_62_542 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_19_349 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_42_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_0969_ net73 _0802_ _0775_ VGND VGND VPWR VPWR _0803_ sky130_fd_sc_hd__mux2_1
XFILLER_0_4_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_10_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_37_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_2_153 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_25_299 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_18_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_60_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_28_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_28_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_9_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1872_ clknet_leaf_22_clk _0012_ VGND VGND VPWR VPWR data\[2\]\[12\] sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_16_244 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1941_ clknet_leaf_18_clk _0081_ VGND VGND VPWR VPWR data\[0\]\[9\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_36_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1306_ net337 _0865_ _0474_ VGND VGND VPWR VPWR _0480_ sky130_fd_sc_hd__mux2_1
X_1099_ net431 _0903_ _0884_ VGND VGND VPWR VPWR _0904_ sky130_fd_sc_hd__mux2_1
X_1168_ data\[0\]\[52\] data\[1\]\[52\] data\[2\]\[52\] data\[3\]\[52\] _0365_ _0372_
+ VGND VGND VPWR VPWR _0387_ sky130_fd_sc_hd__mux4_1
X_1237_ net68 _0439_ _0414_ VGND VGND VPWR VPWR _0440_ sky130_fd_sc_hd__mux2_1
XFILLER_0_59_293 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_18 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_13_225 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_40_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_33_182 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_0_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_2140_ clknet_leaf_29_clk _0280_ VGND VGND VPWR VPWR data\[3\]\[64\] sky130_fd_sc_hd__dfxtp_1
X_1022_ data\[0\]\[19\] data\[1\]\[19\] data\[2\]\[19\] data\[3\]\[19\] _0833_ _0840_
+ VGND VGND VPWR VPWR _0844_ sky130_fd_sc_hd__mux4_1
X_2071_ clknet_leaf_1_clk _0211_ VGND VGND VPWR VPWR net140 sky130_fd_sc_hd__dfxtp_1
X_1924_ clknet_leaf_29_clk _0064_ VGND VGND VPWR VPWR data\[2\]\[64\] sky130_fd_sc_hd__dfxtp_1
X_1855_ _0768_ VGND VGND VPWR VPWR _0357_ sky130_fd_sc_hd__clkbuf_1
X_1786_ _0732_ VGND VGND VPWR VPWR _0324_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_21_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_64_Left_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_47_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_27_317 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_1_93 VPWR VGND VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_10_206 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xhold40 data\[2\]\[41\] VGND VGND VPWR VPWR net191 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_30_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold73 data\[3\]\[71\] VGND VGND VPWR VPWR net224 sky130_fd_sc_hd__dlygate4sd3_1
Xhold62 data\[3\]\[59\] VGND VGND VPWR VPWR net213 sky130_fd_sc_hd__dlygate4sd3_1
Xhold95 data\[3\]\[61\] VGND VGND VPWR VPWR net246 sky130_fd_sc_hd__dlygate4sd3_1
Xhold51 data\[1\]\[12\] VGND VGND VPWR VPWR net202 sky130_fd_sc_hd__dlygate4sd3_1
Xhold84 data\[2\]\[12\] VGND VGND VPWR VPWR net235 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_53_266 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1640_ _0655_ VGND VGND VPWR VPWR _0255_ sky130_fd_sc_hd__clkbuf_1
X_1571_ _0619_ VGND VGND VPWR VPWR _0222_ sky130_fd_sc_hd__clkbuf_1
X_2123_ clknet_leaf_5_clk _0263_ VGND VGND VPWR VPWR data\[3\]\[47\] sky130_fd_sc_hd__dfxtp_1
X_2054_ clknet_leaf_2_clk _0194_ VGND VGND VPWR VPWR net122 sky130_fd_sc_hd__dfxtp_1
XFILLER_0_8_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1005_ net10 _0830_ _0814_ VGND VGND VPWR VPWR _0831_ sky130_fd_sc_hd__mux2_1
X_1907_ clknet_leaf_5_clk _0047_ VGND VGND VPWR VPWR data\[2\]\[47\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_4_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1838_ net228 _0419_ _0758_ VGND VGND VPWR VPWR _0760_ sky130_fd_sc_hd__mux2_1
X_1769_ _0723_ VGND VGND VPWR VPWR _0316_ sky130_fd_sc_hd__clkbuf_1
Xoutput96 net96 VGND VGND VPWR VPWR rdata[27] sky130_fd_sc_hd__clkbuf_4
Xoutput85 net85 VGND VGND VPWR VPWR rdata[17] sky130_fd_sc_hd__buf_2
XFILLER_0_53_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1623_ net359 _0887_ _0645_ VGND VGND VPWR VPWR _0647_ sky130_fd_sc_hd__mux2_1
X_1485_ _0573_ VGND VGND VPWR VPWR _0182_ sky130_fd_sc_hd__clkbuf_1
X_1554_ _0609_ VGND VGND VPWR VPWR _0215_ sky130_fd_sc_hd__clkbuf_1
.ends
